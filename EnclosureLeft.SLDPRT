ISO-10303-21;
HEADER;
FILE_DESCRIPTION(('STEP AP214'),'2;1');
FILE_NAME('part.step','',(''),(''),'','','');
FILE_SCHEMA(('AUTOMOTIVE_DESIGN { 1 0 10303 214 1 1 1 1 }'));
ENDSEC;
DATA;
#1=APPLICATION_CONTEXT('core data for automotive mechanical design processes');
#2=APPLICATION_PROTOCOL_DEFINITION('international standard','automotive_design',2000,#1);
#3=PRODUCT_CONTEXT('',#1,'mechanical');
#4=PRODUCT('Part','Part','',(#3));
#5=PRODUCT_RELATED_PRODUCT_CATEGORY('part','',(#4));
#6=PRODUCT_DEFINITION_FORMATION('','',#4);
#7=PRODUCT_DEFINITION_CONTEXT('part definition',#1,'design');
#8=PRODUCT_DEFINITION('design','',#6,#7);
#9=PRODUCT_DEFINITION_SHAPE('','',#8);
#10=(LENGTH_UNIT() NAMED_UNIT(*) SI_UNIT(.MILLI.,.METRE.));
#11=(NAMED_UNIT(*) PLANE_ANGLE_UNIT() SI_UNIT($,.RADIAN.));
#12=(NAMED_UNIT(*) SI_UNIT($,.STERADIAN.) SOLID_ANGLE_UNIT());
#13=UNCERTAINTY_MEASURE_WITH_UNIT(LENGTH_MEASURE(1.E-05),#10,'distance_accuracy_value','');
#14=(GEOMETRIC_REPRESENTATION_CONTEXT(3) GLOBAL_UNCERTAINTY_ASSIGNED_CONTEXT((#13)) GLOBAL_UNIT_ASSIGNED_CONTEXT((#10,
#11,#12)) REPRESENTATION_CONTEXT('',''));
#15=CARTESIAN_POINT('',(0.,0.,0.));
#16=DIRECTION('',(0.,0.,1.));
#17=DIRECTION('',(1.,0.,0.));
#18=AXIS2_PLACEMENT_3D('',#15,#16,#17);
#19=CARTESIAN_POINT('',(9.525,98.425,-165.1));
#20=DIRECTION('',(0.,0.,1.));
#21=DIRECTION('',(1.,0.,0.));
#22=AXIS2_PLACEMENT_3D('',#19,#20,#21);
#23=PLANE('',#22);
#24=CARTESIAN_POINT('',(4.7624999999992,-76.2,-165.1));
#25=DIRECTION('',(0.,0.,-1.));
#26=DIRECTION('',(-1.,0.,0.));
#27=AXIS2_PLACEMENT_3D('',#24,#25,#26);
#28=CIRCLE('',#27,2.1971);
#29=CARTESIAN_POINT('',(2.5653999999992,-76.2,-165.1));
#30=VERTEX_POINT('',#29);
#31=EDGE_CURVE('E197',#30,#30,#28,.T.);
#32=ORIENTED_EDGE('',*,*,#31,.F.);
#33=EDGE_LOOP('',(#32));
#34=FACE_BOUND('',#33,.T.);
#35=CARTESIAN_POINT('',(4.76250000000027,76.2,-165.1));
#36=DIRECTION('',(0.,0.,-1.));
#37=DIRECTION('',(-1.,0.,0.));
#38=AXIS2_PLACEMENT_3D('',#35,#36,#37);
#39=CIRCLE('',#38,2.1971);
#40=CARTESIAN_POINT('',(2.56540000000027,76.2,-165.1));
#41=VERTEX_POINT('',#40);
#42=EDGE_CURVE('E203',#41,#41,#39,.T.);
#43=ORIENTED_EDGE('',*,*,#42,.F.);
#44=EDGE_LOOP('',(#43));
#45=FACE_BOUND('',#44,.T.);
#46=CARTESIAN_POINT('',(4.7625,0.,-165.1));
#47=DIRECTION('',(0.,0.,-1.));
#48=DIRECTION('',(-1.,0.,0.));
#49=AXIS2_PLACEMENT_3D('',#46,#47,#48);
#50=CIRCLE('',#49,2.1971);
#51=CARTESIAN_POINT('',(2.5654,0.,-165.1));
#52=VERTEX_POINT('',#51);
#53=EDGE_CURVE('E191',#52,#52,#50,.T.);
#54=ORIENTED_EDGE('',*,*,#53,.F.);
#55=EDGE_LOOP('',(#54));
#56=FACE_BOUND('',#55,.T.);
#57=DIRECTION('',(0.,1.,0.));
#58=VECTOR('',#57,1.);
#59=CARTESIAN_POINT('',(0.,98.425,-165.1));
#60=LINE('',#59,#58);
#61=CARTESIAN_POINT('',(0.,-98.425,-165.1));
#62=VERTEX_POINT('',#61);
#63=CARTESIAN_POINT('',(0.,98.425,-165.1));
#64=VERTEX_POINT('',#63);
#65=EDGE_CURVE('E99',#62,#64,#60,.T.);
#66=ORIENTED_EDGE('',*,*,#65,.T.);
#67=DIRECTION('',(-1.,0.,0.));
#68=VECTOR('',#67,1.);
#69=CARTESIAN_POINT('',(9.525,98.425,-165.1));
#70=LINE('',#69,#68);
#71=CARTESIAN_POINT('',(9.525,98.425,-165.1));
#72=VERTEX_POINT('',#71);
#73=EDGE_CURVE('E11',#72,#64,#70,.T.);
#74=ORIENTED_EDGE('',*,*,#73,.F.);
#75=DIRECTION('',(0.,1.,0.));
#76=VECTOR('',#75,1.);
#77=CARTESIAN_POINT('',(9.525,98.425,-165.1));
#78=LINE('',#77,#76);
#79=CARTESIAN_POINT('',(9.525,-98.425,-165.1));
#80=VERTEX_POINT('',#79);
#81=EDGE_CURVE('E87',#80,#72,#78,.T.);
#82=ORIENTED_EDGE('',*,*,#81,.F.);
#83=DIRECTION('',(-1.,0.,0.));
#84=VECTOR('',#83,1.);
#85=CARTESIAN_POINT('',(9.525,-98.425,-165.1));
#86=LINE('',#85,#84);
#87=EDGE_CURVE('E95',#80,#62,#86,.T.);
#88=ORIENTED_EDGE('',*,*,#87,.T.);
#89=EDGE_LOOP('',(#66,#74,#82,#88));
#90=FACE_BOUND('',#89,.T.);
#91=ADVANCED_FACE('F36',(#34,#45,#56,#90),#23,.F.);
#92=CARTESIAN_POINT('',(9.525,98.425,165.1));
#93=DIRECTION('',(0.,-1.,0.));
#94=DIRECTION('',(0.,0.,-1.));
#95=AXIS2_PLACEMENT_3D('',#92,#93,#94);
#96=PLANE('',#95);
#97=CARTESIAN_POINT('',(4.76250000000376,98.425,152.4));
#98=DIRECTION('',(0.,1.,0.));
#99=DIRECTION('',(0.,0.,1.));
#100=AXIS2_PLACEMENT_3D('',#97,#98,#99);
#101=CIRCLE('',#100,2.1971);
#102=CARTESIAN_POINT('',(4.76250000000376,98.425,154.5971));
#103=VERTEX_POINT('',#102);
#104=EDGE_CURVE('E119',#103,#103,#101,.T.);
#105=ORIENTED_EDGE('',*,*,#104,.F.);
#106=EDGE_LOOP('',(#105));
#107=FACE_BOUND('',#106,.T.);
#108=CARTESIAN_POINT('',(4.76250000000188,98.425,76.2));
#109=DIRECTION('',(0.,1.,0.));
#110=DIRECTION('',(0.,0.,1.));
#111=AXIS2_PLACEMENT_3D('',#108,#109,#110);
#112=CIRCLE('',#111,2.1971);
#113=CARTESIAN_POINT('',(4.76250000000188,98.425,78.3971));
#114=VERTEX_POINT('',#113);
#115=EDGE_CURVE('E126',#114,#114,#112,.T.);
#116=ORIENTED_EDGE('',*,*,#115,.F.);
#117=EDGE_LOOP('',(#116));
#118=FACE_BOUND('',#117,.T.);
#119=CARTESIAN_POINT('',(4.76249999999947,98.425,-152.4));
#120=DIRECTION('',(0.,1.,0.));
#121=DIRECTION('',(0.,0.,1.));
#122=AXIS2_PLACEMENT_3D('',#119,#120,#121);
#123=CIRCLE('',#122,2.1971);
#124=CARTESIAN_POINT('',(4.76249999999947,98.425,-150.2029));
#125=VERTEX_POINT('',#124);
#126=EDGE_CURVE('E132',#125,#125,#123,.T.);
#127=ORIENTED_EDGE('',*,*,#126,.F.);
#128=EDGE_LOOP('',(#127));
#129=FACE_BOUND('',#128,.T.);
#130=CARTESIAN_POINT('',(4.76249999999974,98.425,-76.2));
#131=DIRECTION('',(0.,1.,0.));
#132=DIRECTION('',(0.,0.,1.));
#133=AXIS2_PLACEMENT_3D('',#130,#131,#132);
#134=CIRCLE('',#133,2.1971);
#135=CARTESIAN_POINT('',(4.76249999999974,98.425,-74.0029));
#136=VERTEX_POINT('',#135);
#137=EDGE_CURVE('E138',#136,#136,#134,.T.);
#138=ORIENTED_EDGE('',*,*,#137,.F.);
#139=EDGE_LOOP('',(#138));
#140=FACE_BOUND('',#139,.T.);
#141=CARTESIAN_POINT('',(4.7625,98.425,0.));
#142=DIRECTION('',(0.,1.,0.));
#143=DIRECTION('',(0.,0.,1.));
#144=AXIS2_PLACEMENT_3D('',#141,#142,#143);
#145=CIRCLE('',#144,2.1971);
#146=CARTESIAN_POINT('',(4.7625,98.425,2.19710000000003));
#147=VERTEX_POINT('',#146);
#148=EDGE_CURVE('E113',#147,#147,#145,.T.);
#149=ORIENTED_EDGE('',*,*,#148,.F.);
#150=EDGE_LOOP('',(#149));
#151=FACE_BOUND('',#150,.T.);
#152=DIRECTION('',(0.,0.,1.));
#153=VECTOR('',#152,1.);
#154=CARTESIAN_POINT('',(0.,98.425,165.1));
#155=LINE('',#154,#153);
#156=CARTESIAN_POINT('',(0.,98.425,165.1));
#157=VERTEX_POINT('',#156);
#158=EDGE_CURVE('E91',#64,#157,#155,.T.);
#159=ORIENTED_EDGE('',*,*,#158,.T.);
#160=DIRECTION('',(-1.,0.,0.));
#161=VECTOR('',#160,1.);
#162=CARTESIAN_POINT('',(9.525,98.425,165.1));
#163=LINE('',#162,#161);
#164=CARTESIAN_POINT('',(9.525,98.425,165.1));
#165=VERTEX_POINT('',#164);
#166=EDGE_CURVE('E44',#165,#157,#163,.T.);
#167=ORIENTED_EDGE('',*,*,#166,.F.);
#168=DIRECTION('',(0.,0.,1.));
#169=VECTOR('',#168,1.);
#170=CARTESIAN_POINT('',(9.525,98.425,165.1));
#171=LINE('',#170,#169);
#172=EDGE_CURVE('E82',#72,#165,#171,.T.);
#173=ORIENTED_EDGE('',*,*,#172,.F.);
#174=ORIENTED_EDGE('',*,*,#73,.T.);
#175=EDGE_LOOP('',(#159,#167,#173,#174));
#176=FACE_BOUND('',#175,.T.);
#177=ADVANCED_FACE('F90',(#107,#118,#129,#140,#151,#176),#96,.F.);
#178=CARTESIAN_POINT('',(9.525,98.425,165.1));
#179=DIRECTION('',(0.,0.,-1.));
#180=DIRECTION('',(0.,1.,0.));
#181=AXIS2_PLACEMENT_3D('',#178,#179,#180);
#182=PLANE('',#181);
#183=CARTESIAN_POINT('',(4.7625000000008,-76.2,165.1));
#184=DIRECTION('',(0.,0.,1.));
#185=DIRECTION('',(1.,0.,0.));
#186=AXIS2_PLACEMENT_3D('',#183,#184,#185);
#187=CIRCLE('',#186,2.1971);
#188=CARTESIAN_POINT('',(6.9596000000008,-76.2,165.1));
#189=VERTEX_POINT('',#188);
#190=EDGE_CURVE('E149',#189,#189,#187,.T.);
#191=ORIENTED_EDGE('',*,*,#190,.F.);
#192=EDGE_LOOP('',(#191));
#193=FACE_BOUND('',#192,.T.);
#194=CARTESIAN_POINT('',(4.76249999999974,76.2,165.1));
#195=DIRECTION('',(0.,0.,1.));
#196=DIRECTION('',(1.,0.,0.));
#197=AXIS2_PLACEMENT_3D('',#194,#195,#196);
#198=CIRCLE('',#197,2.1971);
#199=CARTESIAN_POINT('',(6.95959999999974,76.2,165.1));
#200=VERTEX_POINT('',#199);
#201=EDGE_CURVE('E156',#200,#200,#198,.T.);
#202=ORIENTED_EDGE('',*,*,#201,.F.);
#203=EDGE_LOOP('',(#202));
#204=FACE_BOUND('',#203,.T.);
#205=CARTESIAN_POINT('',(4.7625,0.,165.1));
#206=DIRECTION('',(0.,0.,1.));
#207=DIRECTION('',(1.,0.,0.));
#208=AXIS2_PLACEMENT_3D('',#205,#206,#207);
#209=CIRCLE('',#208,2.1971);
#210=CARTESIAN_POINT('',(6.9596,0.,165.1));
#211=VERTEX_POINT('',#210);
#212=EDGE_CURVE('E143',#211,#211,#209,.T.);
#213=ORIENTED_EDGE('',*,*,#212,.F.);
#214=EDGE_LOOP('',(#213));
#215=FACE_BOUND('',#214,.T.);
#216=DIRECTION('',(0.,-1.,0.));
#217=VECTOR('',#216,1.);
#218=CARTESIAN_POINT('',(0.,98.425,165.1));
#219=LINE('',#218,#217);
#220=CARTESIAN_POINT('',(0.,-98.425,165.1));
#221=VERTEX_POINT('',#220);
#222=EDGE_CURVE('E69',#157,#221,#219,.T.);
#223=ORIENTED_EDGE('',*,*,#222,.T.);
#224=DIRECTION('',(-1.,0.,0.));
#225=VECTOR('',#224,1.);
#226=CARTESIAN_POINT('',(9.525,-98.425,165.1));
#227=LINE('',#226,#225);
#228=CARTESIAN_POINT('',(9.525,-98.425,165.1));
#229=VERTEX_POINT('',#228);
#230=EDGE_CURVE('E92',#229,#221,#227,.T.);
#231=ORIENTED_EDGE('',*,*,#230,.F.);
#232=DIRECTION('',(0.,-1.,0.));
#233=VECTOR('',#232,1.);
#234=CARTESIAN_POINT('',(9.525,98.425,165.1));
#235=LINE('',#234,#233);
#236=EDGE_CURVE('E85',#165,#229,#235,.T.);
#237=ORIENTED_EDGE('',*,*,#236,.F.);
#238=ORIENTED_EDGE('',*,*,#166,.T.);
#239=EDGE_LOOP('',(#223,#231,#237,#238));
#240=FACE_BOUND('',#239,.T.);
#241=ADVANCED_FACE('F93',(#193,#204,#215,#240),#182,.F.);
#242=CARTESIAN_POINT('',(9.525,-98.425,165.1));
#243=DIRECTION('',(0.,1.,0.));
#244=DIRECTION('',(0.,0.,1.));
#245=AXIS2_PLACEMENT_3D('',#242,#243,#244);
#246=PLANE('',#245);
#247=CARTESIAN_POINT('',(4.76250000000376,-98.425,-152.4));
#248=DIRECTION('',(0.,-1.,0.));
#249=DIRECTION('',(0.,0.,-1.));
#250=AXIS2_PLACEMENT_3D('',#247,#248,#249);
#251=CIRCLE('',#250,2.1971);
#252=CARTESIAN_POINT('',(4.76250000000376,-98.425,-154.5971));
#253=VERTEX_POINT('',#252);
#254=EDGE_CURVE('E167',#253,#253,#251,.T.);
#255=ORIENTED_EDGE('',*,*,#254,.F.);
#256=EDGE_LOOP('',(#255));
#257=FACE_BOUND('',#256,.T.);
#258=CARTESIAN_POINT('',(4.76250000000188,-98.425,-76.2));
#259=DIRECTION('',(0.,-1.,0.));
#260=DIRECTION('',(0.,0.,-1.));
#261=AXIS2_PLACEMENT_3D('',#258,#259,#260);
#262=CIRCLE('',#261,2.1971);
#263=CARTESIAN_POINT('',(4.76250000000188,-98.425,-78.3971));
#264=VERTEX_POINT('',#263);
#265=EDGE_CURVE('E174',#264,#264,#262,.T.);
#266=ORIENTED_EDGE('',*,*,#265,.F.);
#267=EDGE_LOOP('',(#266));
#268=FACE_BOUND('',#267,.T.);
#269=CARTESIAN_POINT('',(4.76249999999947,-98.425,152.4));
#270=DIRECTION('',(0.,-1.,0.));
#271=DIRECTION('',(0.,0.,-1.));
#272=AXIS2_PLACEMENT_3D('',#269,#270,#271);
#273=CIRCLE('',#272,2.1971);
#274=CARTESIAN_POINT('',(4.76249999999947,-98.425,150.2029));
#275=VERTEX_POINT('',#274);
#276=EDGE_CURVE('E180',#275,#275,#273,.T.);
#277=ORIENTED_EDGE('',*,*,#276,.F.);
#278=EDGE_LOOP('',(#277));
#279=FACE_BOUND('',#278,.T.);
#280=CARTESIAN_POINT('',(4.76249999999974,-98.425,76.2));
#281=DIRECTION('',(0.,-1.,0.));
#282=DIRECTION('',(0.,0.,-1.));
#283=AXIS2_PLACEMENT_3D('',#280,#281,#282);
#284=CIRCLE('',#283,2.1971);
#285=CARTESIAN_POINT('',(4.76249999999974,-98.425,74.0029));
#286=VERTEX_POINT('',#285);
#287=EDGE_CURVE('E186',#286,#286,#284,.T.);
#288=ORIENTED_EDGE('',*,*,#287,.F.);
#289=EDGE_LOOP('',(#288));
#290=FACE_BOUND('',#289,.T.);
#291=CARTESIAN_POINT('',(4.7625,-98.425,0.));
#292=DIRECTION('',(0.,-1.,0.));
#293=DIRECTION('',(0.,0.,-1.));
#294=AXIS2_PLACEMENT_3D('',#291,#292,#293);
#295=CIRCLE('',#294,2.1971);
#296=CARTESIAN_POINT('',(4.7625,-98.425,-2.1971));
#297=VERTEX_POINT('',#296);
#298=EDGE_CURVE('E161',#297,#297,#295,.T.);
#299=ORIENTED_EDGE('',*,*,#298,.F.);
#300=EDGE_LOOP('',(#299));
#301=FACE_BOUND('',#300,.T.);
#302=DIRECTION('',(0.,0.,-1.));
#303=VECTOR('',#302,1.);
#304=CARTESIAN_POINT('',(0.,-98.425,165.1));
#305=LINE('',#304,#303);
#306=EDGE_CURVE('E75',#221,#62,#305,.T.);
#307=ORIENTED_EDGE('',*,*,#306,.T.);
#308=ORIENTED_EDGE('',*,*,#87,.F.);
#309=DIRECTION('',(0.,0.,-1.));
#310=VECTOR('',#309,1.);
#311=CARTESIAN_POINT('',(9.525,-98.425,165.1));
#312=LINE('',#311,#310);
#313=EDGE_CURVE('E52',#229,#80,#312,.T.);
#314=ORIENTED_EDGE('',*,*,#313,.F.);
#315=ORIENTED_EDGE('',*,*,#230,.T.);
#316=EDGE_LOOP('',(#307,#308,#314,#315));
#317=FACE_BOUND('',#316,.T.);
#318=ADVANCED_FACE('F107',(#257,#268,#279,#290,#301,#317),#246,.F.);
#319=CARTESIAN_POINT('',(9.525,0.,0.));
#320=DIRECTION('',(1.,0.,0.));
#321=DIRECTION('',(0.,0.,-1.));
#322=AXIS2_PLACEMENT_3D('',#319,#320,#321);
#323=PLANE('',#322);
#324=ORIENTED_EDGE('',*,*,#81,.T.);
#325=ORIENTED_EDGE('',*,*,#172,.T.);
#326=ORIENTED_EDGE('',*,*,#236,.T.);
#327=ORIENTED_EDGE('',*,*,#313,.T.);
#328=EDGE_LOOP('',(#324,#325,#326,#327));
#329=FACE_BOUND('',#328,.T.);
#330=ADVANCED_FACE('F83',(#329),#323,.T.);
#331=CARTESIAN_POINT('',(0.,0.,0.));
#332=DIRECTION('',(1.,0.,0.));
#333=DIRECTION('',(0.,0.,-1.));
#334=AXIS2_PLACEMENT_3D('',#331,#332,#333);
#335=PLANE('',#334);
#336=ORIENTED_EDGE('',*,*,#65,.F.);
#337=ORIENTED_EDGE('',*,*,#306,.F.);
#338=ORIENTED_EDGE('',*,*,#222,.F.);
#339=ORIENTED_EDGE('',*,*,#158,.F.);
#340=EDGE_LOOP('',(#336,#337,#338,#339));
#341=FACE_BOUND('',#340,.T.);
#342=ADVANCED_FACE('F110',(#341),#335,.F.);
#343=CARTESIAN_POINT('',(4.7625,83.185,0.));
#344=DIRECTION('',(0.,1.,0.));
#345=DIRECTION('',(0.,0.,1.));
#346=AXIS2_PLACEMENT_3D('',#343,#344,#345);
#347=CYLINDRICAL_SURFACE('',#346,2.1971);
#348=CARTESIAN_POINT('',(4.7625,83.185,0.));
#349=DIRECTION('',(0.,1.,0.));
#350=DIRECTION('',(0.,0.,1.));
#351=AXIS2_PLACEMENT_3D('',#348,#349,#350);
#352=CIRCLE('',#351,2.1971);
#353=CARTESIAN_POINT('',(4.7625,83.185,2.19710000000003));
#354=VERTEX_POINT('',#353);
#355=EDGE_CURVE('E102',#354,#354,#352,.T.);
#356=CARTESIAN_POINT('',(4.7625,83.185,2.19710000000003));
#357=CARTESIAN_POINT('',(4.7625,83.34375,2.19710000000003));
#358=CARTESIAN_POINT('',(4.7625,83.5025,2.19710000000003));
#359=CARTESIAN_POINT('',(4.7625,83.82,2.19710000000003));
#360=CARTESIAN_POINT('',(4.7625,83.97875,2.19710000000003));
#361=CARTESIAN_POINT('',(4.7625,84.29625,2.19710000000003));
#362=CARTESIAN_POINT('',(4.7625,84.455,2.19710000000003));
#363=CARTESIAN_POINT('',(4.7625,84.7725,2.19710000000003));
#364=CARTESIAN_POINT('',(4.7625,84.93125,2.19710000000003));
#365=CARTESIAN_POINT('',(4.7625,85.24875,2.19710000000003));
#366=CARTESIAN_POINT('',(4.7625,85.4075,2.19710000000003));
#367=CARTESIAN_POINT('',(4.7625,85.725,2.19710000000003));
#368=CARTESIAN_POINT('',(4.7625,85.88375,2.19710000000003));
#369=CARTESIAN_POINT('',(4.7625,86.20125,2.19710000000003));
#370=CARTESIAN_POINT('',(4.7625,86.36,2.19710000000003));
#371=CARTESIAN_POINT('',(4.7625,86.6775,2.19710000000003));
#372=CARTESIAN_POINT('',(4.7625,86.83625,2.19710000000003));
#373=CARTESIAN_POINT('',(4.7625,87.15375,2.19710000000003));
#374=CARTESIAN_POINT('',(4.7625,87.3125,2.19710000000003));
#375=CARTESIAN_POINT('',(4.7625,87.63,2.19710000000003));
#376=CARTESIAN_POINT('',(4.7625,87.78875,2.19710000000003));
#377=CARTESIAN_POINT('',(4.7625,88.10625,2.19710000000003));
#378=CARTESIAN_POINT('',(4.7625,88.265,2.19710000000003));
#379=CARTESIAN_POINT('',(4.7625,88.5825,2.19710000000003));
#380=CARTESIAN_POINT('',(4.7625,88.74125,2.19710000000003));
#381=CARTESIAN_POINT('',(4.7625,89.05875,2.19710000000003));
#382=CARTESIAN_POINT('',(4.7625,89.2175,2.19710000000003));
#383=CARTESIAN_POINT('',(4.7625,89.535,2.19710000000003));
#384=CARTESIAN_POINT('',(4.7625,89.69375,2.19710000000003));
#385=CARTESIAN_POINT('',(4.7625,90.01125,2.19710000000003));
#386=CARTESIAN_POINT('',(4.7625,90.17,2.19710000000003));
#387=CARTESIAN_POINT('',(4.7625,90.4875,2.19710000000003));
#388=CARTESIAN_POINT('',(4.7625,90.64625,2.19710000000003));
#389=CARTESIAN_POINT('',(4.7625,90.96375,2.19710000000003));
#390=CARTESIAN_POINT('',(4.7625,91.1225,2.19710000000003));
#391=CARTESIAN_POINT('',(4.7625,91.44,2.19710000000003));
#392=CARTESIAN_POINT('',(4.7625,91.59875,2.19710000000003));
#393=CARTESIAN_POINT('',(4.7625,91.91625,2.19710000000003));
#394=CARTESIAN_POINT('',(4.7625,92.075,2.19710000000003));
#395=CARTESIAN_POINT('',(4.7625,92.3925,2.19710000000003));
#396=CARTESIAN_POINT('',(4.7625,92.55125,2.19710000000003));
#397=CARTESIAN_POINT('',(4.7625,92.86875,2.19710000000003));
#398=CARTESIAN_POINT('',(4.7625,93.0275,2.19710000000003));
#399=CARTESIAN_POINT('',(4.7625,93.345,2.19710000000003));
#400=CARTESIAN_POINT('',(4.7625,93.50375,2.19710000000003));
#401=CARTESIAN_POINT('',(4.7625,93.82125,2.19710000000003));
#402=CARTESIAN_POINT('',(4.7625,93.98,2.19710000000003));
#403=CARTESIAN_POINT('',(4.7625,94.2975,2.19710000000003));
#404=CARTESIAN_POINT('',(4.7625,94.45625,2.19710000000003));
#405=CARTESIAN_POINT('',(4.7625,94.77375,2.19710000000003));
#406=CARTESIAN_POINT('',(4.7625,94.9325,2.19710000000003));
#407=CARTESIAN_POINT('',(4.7625,95.25,2.19710000000003));
#408=CARTESIAN_POINT('',(4.7625,95.40875,2.19710000000003));
#409=CARTESIAN_POINT('',(4.7625,95.72625,2.19710000000003));
#410=CARTESIAN_POINT('',(4.7625,95.885,2.19710000000003));
#411=CARTESIAN_POINT('',(4.7625,96.2025,2.19710000000003));
#412=CARTESIAN_POINT('',(4.7625,96.36125,2.19710000000003));
#413=CARTESIAN_POINT('',(4.7625,96.67875,2.19710000000003));
#414=CARTESIAN_POINT('',(4.7625,96.8375,2.19710000000003));
#415=CARTESIAN_POINT('',(4.7625,97.155,2.19710000000003));
#416=CARTESIAN_POINT('',(4.7625,97.31375,2.19710000000003));
#417=CARTESIAN_POINT('',(4.7625,97.63125,2.19710000000003));
#418=CARTESIAN_POINT('',(4.7625,97.79,2.19710000000003));
#419=CARTESIAN_POINT('',(4.7625,98.1075,2.19710000000003));
#420=CARTESIAN_POINT('',(4.7625,98.26625,2.19710000000003));
#421=CARTESIAN_POINT('',(4.7625,98.425,2.19710000000003));
#422=B_SPLINE_CURVE_WITH_KNOTS('',3,(#356,#357,#358,#359,#360,#361,#362,#363,#364,#365,#366,
#367,#368,#369,#370,#371,#372,#373,#374,#375,#376,#377,#378,#379,#380,#381,#382,#383,#384,#385,
#386,#387,#388,#389,#390,#391,#392,#393,#394,#395,#396,#397,#398,#399,#400,#401,#402,#403,#404,
#405,#406,#407,#408,#409,#410,#411,#412,#413,#414,#415,#416,#417,#418,#419,#420,#421),
.UNSPECIFIED.,.F.,.F.,(4,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,4),(0.,
0.476249999999998,0.952499999999995,1.42874999999999,1.90499999999999,2.38124999999999,2.8575,
3.33375,3.80999999999999,4.28624999999999,4.76249999999999,5.23875,5.715,6.19125,
6.66749999999999,7.14374999999999,7.62,8.09625,8.5725,9.04874999999999,9.52499999999999,
10.00125,10.4775,10.95375,11.43,11.90625,12.3825,12.85875,13.335,13.81125,14.2875,14.76375,
15.24),.UNSPECIFIED.);
#423=EDGE_CURVE('BSEAM334',#354,#147,#422,.T.);
#424=ORIENTED_EDGE('',*,*,#355,.F.);
#425=ORIENTED_EDGE('',*,*,#148,.T.);
#426=ORIENTED_EDGE('',*,*,#423,.T.);
#427=ORIENTED_EDGE('',*,*,#423,.F.);
#428=EDGE_LOOP('',(#424,#426,#425,#427));
#429=FACE_BOUND('',#428,.T.);
#430=ADVANCED_FACE('F334',(#429),#347,.F.);
#431=CARTESIAN_POINT('',(4.7625,83.185,0.));
#432=DIRECTION('',(0.,1.,0.));
#433=DIRECTION('',(0.,0.,1.));
#434=AXIS2_PLACEMENT_3D('',#431,#432,#433);
#435=PLANE('',#434);
#436=ORIENTED_EDGE('',*,*,#355,.T.);
#437=EDGE_LOOP('',(#436));
#438=FACE_BOUND('',#437,.T.);
#439=ADVANCED_FACE('F308',(#438),#435,.T.);
#440=CARTESIAN_POINT('',(4.76249999999974,83.185,-76.2));
#441=DIRECTION('',(0.,1.,0.));
#442=DIRECTION('',(0.,0.,1.));
#443=AXIS2_PLACEMENT_3D('',#440,#441,#442);
#444=CYLINDRICAL_SURFACE('',#443,2.1971);
#445=CARTESIAN_POINT('',(4.76249999999974,83.185,-76.2));
#446=DIRECTION('',(0.,1.,0.));
#447=DIRECTION('',(0.,0.,1.));
#448=AXIS2_PLACEMENT_3D('',#445,#446,#447);
#449=CIRCLE('',#448,2.1971);
#450=CARTESIAN_POINT('',(4.76249999999974,83.185,-74.0029));
#451=VERTEX_POINT('',#450);
#452=EDGE_CURVE('E116',#451,#451,#449,.T.);
#453=CARTESIAN_POINT('',(4.76249999999974,83.185,-74.0029));
#454=CARTESIAN_POINT('',(4.76249999999974,83.34375,-74.0029));
#455=CARTESIAN_POINT('',(4.76249999999974,83.5025,-74.0029));
#456=CARTESIAN_POINT('',(4.76249999999974,83.82,-74.0029));
#457=CARTESIAN_POINT('',(4.76249999999974,83.97875,-74.0029));
#458=CARTESIAN_POINT('',(4.76249999999974,84.29625,-74.0029));
#459=CARTESIAN_POINT('',(4.76249999999974,84.455,-74.0029));
#460=CARTESIAN_POINT('',(4.76249999999974,84.7725,-74.0029));
#461=CARTESIAN_POINT('',(4.76249999999974,84.93125,-74.0029));
#462=CARTESIAN_POINT('',(4.76249999999974,85.24875,-74.0029));
#463=CARTESIAN_POINT('',(4.76249999999974,85.4075,-74.0029));
#464=CARTESIAN_POINT('',(4.76249999999974,85.725,-74.0029));
#465=CARTESIAN_POINT('',(4.76249999999974,85.88375,-74.0029));
#466=CARTESIAN_POINT('',(4.76249999999974,86.20125,-74.0029));
#467=CARTESIAN_POINT('',(4.76249999999974,86.36,-74.0029));
#468=CARTESIAN_POINT('',(4.76249999999974,86.6775,-74.0029));
#469=CARTESIAN_POINT('',(4.76249999999974,86.83625,-74.0029));
#470=CARTESIAN_POINT('',(4.76249999999974,87.15375,-74.0029));
#471=CARTESIAN_POINT('',(4.76249999999974,87.3125,-74.0029));
#472=CARTESIAN_POINT('',(4.76249999999974,87.63,-74.0029));
#473=CARTESIAN_POINT('',(4.76249999999974,87.78875,-74.0029));
#474=CARTESIAN_POINT('',(4.76249999999974,88.10625,-74.0029));
#475=CARTESIAN_POINT('',(4.76249999999974,88.265,-74.0029));
#476=CARTESIAN_POINT('',(4.76249999999974,88.5825,-74.0029));
#477=CARTESIAN_POINT('',(4.76249999999974,88.74125,-74.0029));
#478=CARTESIAN_POINT('',(4.76249999999974,89.05875,-74.0029));
#479=CARTESIAN_POINT('',(4.76249999999974,89.2175,-74.0029));
#480=CARTESIAN_POINT('',(4.76249999999974,89.535,-74.0029));
#481=CARTESIAN_POINT('',(4.76249999999974,89.69375,-74.0029));
#482=CARTESIAN_POINT('',(4.76249999999974,90.01125,-74.0029));
#483=CARTESIAN_POINT('',(4.76249999999974,90.17,-74.0029));
#484=CARTESIAN_POINT('',(4.76249999999974,90.4875,-74.0029));
#485=CARTESIAN_POINT('',(4.76249999999974,90.64625,-74.0029));
#486=CARTESIAN_POINT('',(4.76249999999974,90.96375,-74.0029));
#487=CARTESIAN_POINT('',(4.76249999999974,91.1225,-74.0029));
#488=CARTESIAN_POINT('',(4.76249999999974,91.44,-74.0029));
#489=CARTESIAN_POINT('',(4.76249999999974,91.59875,-74.0029));
#490=CARTESIAN_POINT('',(4.76249999999974,91.91625,-74.0029));
#491=CARTESIAN_POINT('',(4.76249999999974,92.075,-74.0029));
#492=CARTESIAN_POINT('',(4.76249999999974,92.3925,-74.0029));
#493=CARTESIAN_POINT('',(4.76249999999974,92.55125,-74.0029));
#494=CARTESIAN_POINT('',(4.76249999999974,92.86875,-74.0029));
#495=CARTESIAN_POINT('',(4.76249999999974,93.0275,-74.0029));
#496=CARTESIAN_POINT('',(4.76249999999974,93.345,-74.0029));
#497=CARTESIAN_POINT('',(4.76249999999974,93.50375,-74.0029));
#498=CARTESIAN_POINT('',(4.76249999999974,93.82125,-74.0029));
#499=CARTESIAN_POINT('',(4.76249999999974,93.98,-74.0029));
#500=CARTESIAN_POINT('',(4.76249999999974,94.2975,-74.0029));
#501=CARTESIAN_POINT('',(4.76249999999974,94.45625,-74.0029));
#502=CARTESIAN_POINT('',(4.76249999999974,94.77375,-74.0029));
#503=CARTESIAN_POINT('',(4.76249999999974,94.9325,-74.0029));
#504=CARTESIAN_POINT('',(4.76249999999974,95.25,-74.0029));
#505=CARTESIAN_POINT('',(4.76249999999974,95.40875,-74.0029));
#506=CARTESIAN_POINT('',(4.76249999999974,95.72625,-74.0029));
#507=CARTESIAN_POINT('',(4.76249999999974,95.885,-74.0029));
#508=CARTESIAN_POINT('',(4.76249999999974,96.2025,-74.0029));
#509=CARTESIAN_POINT('',(4.76249999999974,96.36125,-74.0029));
#510=CARTESIAN_POINT('',(4.76249999999974,96.67875,-74.0029));
#511=CARTESIAN_POINT('',(4.76249999999974,96.8375,-74.0029));
#512=CARTESIAN_POINT('',(4.76249999999974,97.155,-74.0029));
#513=CARTESIAN_POINT('',(4.76249999999974,97.31375,-74.0029));
#514=CARTESIAN_POINT('',(4.76249999999974,97.63125,-74.0029));
#515=CARTESIAN_POINT('',(4.76249999999974,97.79,-74.0029));
#516=CARTESIAN_POINT('',(4.76249999999974,98.1075,-74.0029));
#517=CARTESIAN_POINT('',(4.76249999999974,98.26625,-74.0029));
#518=CARTESIAN_POINT('',(4.76249999999974,98.425,-74.0029));
#519=B_SPLINE_CURVE_WITH_KNOTS('',3,(#453,#454,#455,#456,#457,#458,#459,#460,#461,#462,#463,
#464,#465,#466,#467,#468,#469,#470,#471,#472,#473,#474,#475,#476,#477,#478,#479,#480,#481,#482,
#483,#484,#485,#486,#487,#488,#489,#490,#491,#492,#493,#494,#495,#496,#497,#498,#499,#500,#501,
#502,#503,#504,#505,#506,#507,#508,#509,#510,#511,#512,#513,#514,#515,#516,#517,#518),
.UNSPECIFIED.,.F.,.F.,(4,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,4),(0.,
0.476249999999998,0.952499999999995,1.42874999999999,1.90499999999999,2.38124999999999,2.8575,
3.33375,3.80999999999999,4.28624999999999,4.76249999999999,5.23875,5.715,6.19125,
6.66749999999999,7.14374999999999,7.62,8.09625,8.5725,9.04874999999999,9.52499999999999,
10.00125,10.4775,10.95375,11.43,11.90625,12.3825,12.85875,13.335,13.81125,14.2875,14.76375,
15.24),.UNSPECIFIED.);
#520=EDGE_CURVE('BSEAM304',#451,#136,#519,.T.);
#521=ORIENTED_EDGE('',*,*,#452,.F.);
#522=ORIENTED_EDGE('',*,*,#137,.T.);
#523=ORIENTED_EDGE('',*,*,#520,.T.);
#524=ORIENTED_EDGE('',*,*,#520,.F.);
#525=EDGE_LOOP('',(#521,#523,#522,#524));
#526=FACE_BOUND('',#525,.T.);
#527=ADVANCED_FACE('F304',(#526),#444,.F.);
#528=CARTESIAN_POINT('',(4.76249999999974,83.185,-76.2));
#529=DIRECTION('',(0.,1.,0.));
#530=DIRECTION('',(0.,0.,1.));
#531=AXIS2_PLACEMENT_3D('',#528,#529,#530);
#532=PLANE('',#531);
#533=ORIENTED_EDGE('',*,*,#452,.T.);
#534=EDGE_LOOP('',(#533));
#535=FACE_BOUND('',#534,.T.);
#536=ADVANCED_FACE('F300',(#535),#532,.T.);
#537=CARTESIAN_POINT('',(4.76249999999947,83.185,-152.4));
#538=DIRECTION('',(0.,1.,0.));
#539=DIRECTION('',(0.,0.,1.));
#540=AXIS2_PLACEMENT_3D('',#537,#538,#539);
#541=CYLINDRICAL_SURFACE('',#540,2.1971);
#542=CARTESIAN_POINT('',(4.76249999999947,83.185,-152.4));
#543=DIRECTION('',(0.,1.,0.));
#544=DIRECTION('',(0.,0.,1.));
#545=AXIS2_PLACEMENT_3D('',#542,#543,#544);
#546=CIRCLE('',#545,2.1971);
#547=CARTESIAN_POINT('',(4.76249999999947,83.185,-150.2029));
#548=VERTEX_POINT('',#547);
#549=EDGE_CURVE('E135',#548,#548,#546,.T.);
#550=CARTESIAN_POINT('',(4.76249999999947,83.185,-150.2029));
#551=CARTESIAN_POINT('',(4.76249999999947,83.34375,-150.2029));
#552=CARTESIAN_POINT('',(4.76249999999947,83.5025,-150.2029));
#553=CARTESIAN_POINT('',(4.76249999999947,83.82,-150.2029));
#554=CARTESIAN_POINT('',(4.76249999999947,83.97875,-150.2029));
#555=CARTESIAN_POINT('',(4.76249999999947,84.29625,-150.2029));
#556=CARTESIAN_POINT('',(4.76249999999947,84.455,-150.2029));
#557=CARTESIAN_POINT('',(4.76249999999947,84.7725,-150.2029));
#558=CARTESIAN_POINT('',(4.76249999999947,84.93125,-150.2029));
#559=CARTESIAN_POINT('',(4.76249999999947,85.24875,-150.2029));
#560=CARTESIAN_POINT('',(4.76249999999947,85.4075,-150.2029));
#561=CARTESIAN_POINT('',(4.76249999999947,85.725,-150.2029));
#562=CARTESIAN_POINT('',(4.76249999999947,85.88375,-150.2029));
#563=CARTESIAN_POINT('',(4.76249999999947,86.20125,-150.2029));
#564=CARTESIAN_POINT('',(4.76249999999947,86.36,-150.2029));
#565=CARTESIAN_POINT('',(4.76249999999947,86.6775,-150.2029));
#566=CARTESIAN_POINT('',(4.76249999999947,86.83625,-150.2029));
#567=CARTESIAN_POINT('',(4.76249999999947,87.15375,-150.2029));
#568=CARTESIAN_POINT('',(4.76249999999947,87.3125,-150.2029));
#569=CARTESIAN_POINT('',(4.76249999999947,87.63,-150.2029));
#570=CARTESIAN_POINT('',(4.76249999999947,87.78875,-150.2029));
#571=CARTESIAN_POINT('',(4.76249999999947,88.10625,-150.2029));
#572=CARTESIAN_POINT('',(4.76249999999947,88.265,-150.2029));
#573=CARTESIAN_POINT('',(4.76249999999947,88.5825,-150.2029));
#574=CARTESIAN_POINT('',(4.76249999999947,88.74125,-150.2029));
#575=CARTESIAN_POINT('',(4.76249999999947,89.05875,-150.2029));
#576=CARTESIAN_POINT('',(4.76249999999947,89.2175,-150.2029));
#577=CARTESIAN_POINT('',(4.76249999999947,89.535,-150.2029));
#578=CARTESIAN_POINT('',(4.76249999999947,89.69375,-150.2029));
#579=CARTESIAN_POINT('',(4.76249999999947,90.01125,-150.2029));
#580=CARTESIAN_POINT('',(4.76249999999947,90.17,-150.2029));
#581=CARTESIAN_POINT('',(4.76249999999947,90.4875,-150.2029));
#582=CARTESIAN_POINT('',(4.76249999999947,90.64625,-150.2029));
#583=CARTESIAN_POINT('',(4.76249999999947,90.96375,-150.2029));
#584=CARTESIAN_POINT('',(4.76249999999947,91.1225,-150.2029));
#585=CARTESIAN_POINT('',(4.76249999999947,91.44,-150.2029));
#586=CARTESIAN_POINT('',(4.76249999999947,91.59875,-150.2029));
#587=CARTESIAN_POINT('',(4.76249999999947,91.91625,-150.2029));
#588=CARTESIAN_POINT('',(4.76249999999947,92.075,-150.2029));
#589=CARTESIAN_POINT('',(4.76249999999947,92.3925,-150.2029));
#590=CARTESIAN_POINT('',(4.76249999999947,92.55125,-150.2029));
#591=CARTESIAN_POINT('',(4.76249999999947,92.86875,-150.2029));
#592=CARTESIAN_POINT('',(4.76249999999947,93.0275,-150.2029));
#593=CARTESIAN_POINT('',(4.76249999999947,93.345,-150.2029));
#594=CARTESIAN_POINT('',(4.76249999999947,93.50375,-150.2029));
#595=CARTESIAN_POINT('',(4.76249999999947,93.82125,-150.2029));
#596=CARTESIAN_POINT('',(4.76249999999947,93.98,-150.2029));
#597=CARTESIAN_POINT('',(4.76249999999947,94.2975,-150.2029));
#598=CARTESIAN_POINT('',(4.76249999999947,94.45625,-150.2029));
#599=CARTESIAN_POINT('',(4.76249999999947,94.77375,-150.2029));
#600=CARTESIAN_POINT('',(4.76249999999947,94.9325,-150.2029));
#601=CARTESIAN_POINT('',(4.76249999999947,95.25,-150.2029));
#602=CARTESIAN_POINT('',(4.76249999999947,95.40875,-150.2029));
#603=CARTESIAN_POINT('',(4.76249999999947,95.72625,-150.2029));
#604=CARTESIAN_POINT('',(4.76249999999947,95.885,-150.2029));
#605=CARTESIAN_POINT('',(4.76249999999947,96.2025,-150.2029));
#606=CARTESIAN_POINT('',(4.76249999999947,96.36125,-150.2029));
#607=CARTESIAN_POINT('',(4.76249999999947,96.67875,-150.2029));
#608=CARTESIAN_POINT('',(4.76249999999947,96.8375,-150.2029));
#609=CARTESIAN_POINT('',(4.76249999999947,97.155,-150.2029));
#610=CARTESIAN_POINT('',(4.76249999999947,97.31375,-150.2029));
#611=CARTESIAN_POINT('',(4.76249999999947,97.63125,-150.2029));
#612=CARTESIAN_POINT('',(4.76249999999947,97.79,-150.2029));
#613=CARTESIAN_POINT('',(4.76249999999947,98.1075,-150.2029));
#614=CARTESIAN_POINT('',(4.76249999999947,98.26625,-150.2029));
#615=CARTESIAN_POINT('',(4.76249999999947,98.425,-150.2029));
#616=B_SPLINE_CURVE_WITH_KNOTS('',3,(#550,#551,#552,#553,#554,#555,#556,#557,#558,#559,#560,
#561,#562,#563,#564,#565,#566,#567,#568,#569,#570,#571,#572,#573,#574,#575,#576,#577,#578,#579,
#580,#581,#582,#583,#584,#585,#586,#587,#588,#589,#590,#591,#592,#593,#594,#595,#596,#597,#598,
#599,#600,#601,#602,#603,#604,#605,#606,#607,#608,#609,#610,#611,#612,#613,#614,#615),
.UNSPECIFIED.,.F.,.F.,(4,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,4),(0.,
0.476249999999998,0.952499999999995,1.42874999999999,1.90499999999999,2.38124999999999,2.8575,
3.33375,3.80999999999999,4.28624999999999,4.76249999999999,5.23875,5.715,6.19125,
6.66749999999999,7.14374999999999,7.62,8.09625,8.5725,9.04874999999999,9.52499999999999,
10.00125,10.4775,10.95375,11.43,11.90625,12.3825,12.85875,13.335,13.81125,14.2875,14.76375,
15.24),.UNSPECIFIED.);
#617=EDGE_CURVE('BSEAM303',#548,#125,#616,.T.);
#618=ORIENTED_EDGE('',*,*,#549,.F.);
#619=ORIENTED_EDGE('',*,*,#126,.T.);
#620=ORIENTED_EDGE('',*,*,#617,.T.);
#621=ORIENTED_EDGE('',*,*,#617,.F.);
#622=EDGE_LOOP('',(#618,#620,#619,#621));
#623=FACE_BOUND('',#622,.T.);
#624=ADVANCED_FACE('F303',(#623),#541,.F.);
#625=CARTESIAN_POINT('',(4.76249999999947,83.185,-152.4));
#626=DIRECTION('',(0.,1.,0.));
#627=DIRECTION('',(0.,0.,1.));
#628=AXIS2_PLACEMENT_3D('',#625,#626,#627);
#629=PLANE('',#628);
#630=ORIENTED_EDGE('',*,*,#549,.T.);
#631=EDGE_LOOP('',(#630));
#632=FACE_BOUND('',#631,.T.);
#633=ADVANCED_FACE('F310',(#632),#629,.T.);
#634=CARTESIAN_POINT('',(4.76250000000188,83.185,76.2));
#635=DIRECTION('',(0.,1.,0.));
#636=DIRECTION('',(0.,0.,1.));
#637=AXIS2_PLACEMENT_3D('',#634,#635,#636);
#638=CYLINDRICAL_SURFACE('',#637,2.1971);
#639=CARTESIAN_POINT('',(4.76250000000188,83.185,76.2));
#640=DIRECTION('',(0.,1.,0.));
#641=DIRECTION('',(0.,0.,1.));
#642=AXIS2_PLACEMENT_3D('',#639,#640,#641);
#643=CIRCLE('',#642,2.1971);
#644=CARTESIAN_POINT('',(4.76250000000188,83.185,78.3971));
#645=VERTEX_POINT('',#644);
#646=EDGE_CURVE('E129',#645,#645,#643,.T.);
#647=CARTESIAN_POINT('',(4.76250000000188,83.185,78.3971));
#648=CARTESIAN_POINT('',(4.76250000000188,83.34375,78.3971));
#649=CARTESIAN_POINT('',(4.76250000000188,83.5025,78.3971));
#650=CARTESIAN_POINT('',(4.76250000000188,83.82,78.3971));
#651=CARTESIAN_POINT('',(4.76250000000188,83.97875,78.3971));
#652=CARTESIAN_POINT('',(4.76250000000188,84.29625,78.3971));
#653=CARTESIAN_POINT('',(4.76250000000188,84.455,78.3971));
#654=CARTESIAN_POINT('',(4.76250000000188,84.7725,78.3971));
#655=CARTESIAN_POINT('',(4.76250000000188,84.93125,78.3971));
#656=CARTESIAN_POINT('',(4.76250000000188,85.24875,78.3971));
#657=CARTESIAN_POINT('',(4.76250000000188,85.4075,78.3971));
#658=CARTESIAN_POINT('',(4.76250000000188,85.725,78.3971));
#659=CARTESIAN_POINT('',(4.76250000000188,85.88375,78.3971));
#660=CARTESIAN_POINT('',(4.76250000000188,86.20125,78.3971));
#661=CARTESIAN_POINT('',(4.76250000000188,86.36,78.3971));
#662=CARTESIAN_POINT('',(4.76250000000188,86.6775,78.3971));
#663=CARTESIAN_POINT('',(4.76250000000188,86.83625,78.3971));
#664=CARTESIAN_POINT('',(4.76250000000188,87.15375,78.3971));
#665=CARTESIAN_POINT('',(4.76250000000188,87.3125,78.3971));
#666=CARTESIAN_POINT('',(4.76250000000188,87.63,78.3971));
#667=CARTESIAN_POINT('',(4.76250000000188,87.78875,78.3971));
#668=CARTESIAN_POINT('',(4.76250000000188,88.10625,78.3971));
#669=CARTESIAN_POINT('',(4.76250000000188,88.265,78.3971));
#670=CARTESIAN_POINT('',(4.76250000000188,88.5825,78.3971));
#671=CARTESIAN_POINT('',(4.76250000000188,88.74125,78.3971));
#672=CARTESIAN_POINT('',(4.76250000000188,89.05875,78.3971));
#673=CARTESIAN_POINT('',(4.76250000000188,89.2175,78.3971));
#674=CARTESIAN_POINT('',(4.76250000000188,89.535,78.3971));
#675=CARTESIAN_POINT('',(4.76250000000188,89.69375,78.3971));
#676=CARTESIAN_POINT('',(4.76250000000188,90.01125,78.3971));
#677=CARTESIAN_POINT('',(4.76250000000188,90.17,78.3971));
#678=CARTESIAN_POINT('',(4.76250000000188,90.4875,78.3971));
#679=CARTESIAN_POINT('',(4.76250000000188,90.64625,78.3971));
#680=CARTESIAN_POINT('',(4.76250000000188,90.96375,78.3971));
#681=CARTESIAN_POINT('',(4.76250000000188,91.1225,78.3971));
#682=CARTESIAN_POINT('',(4.76250000000188,91.44,78.3971));
#683=CARTESIAN_POINT('',(4.76250000000188,91.59875,78.3971));
#684=CARTESIAN_POINT('',(4.76250000000188,91.91625,78.3971));
#685=CARTESIAN_POINT('',(4.76250000000188,92.075,78.3971));
#686=CARTESIAN_POINT('',(4.76250000000188,92.3925,78.3971));
#687=CARTESIAN_POINT('',(4.76250000000188,92.55125,78.3971));
#688=CARTESIAN_POINT('',(4.76250000000188,92.86875,78.3971));
#689=CARTESIAN_POINT('',(4.76250000000188,93.0275,78.3971));
#690=CARTESIAN_POINT('',(4.76250000000188,93.345,78.3971));
#691=CARTESIAN_POINT('',(4.76250000000188,93.50375,78.3971));
#692=CARTESIAN_POINT('',(4.76250000000188,93.82125,78.3971));
#693=CARTESIAN_POINT('',(4.76250000000188,93.98,78.3971));
#694=CARTESIAN_POINT('',(4.76250000000188,94.2975,78.3971));
#695=CARTESIAN_POINT('',(4.76250000000188,94.45625,78.3971));
#696=CARTESIAN_POINT('',(4.76250000000188,94.77375,78.3971));
#697=CARTESIAN_POINT('',(4.76250000000188,94.9325,78.3971));
#698=CARTESIAN_POINT('',(4.76250000000188,95.25,78.3971));
#699=CARTESIAN_POINT('',(4.76250000000188,95.40875,78.3971));
#700=CARTESIAN_POINT('',(4.76250000000188,95.72625,78.3971));
#701=CARTESIAN_POINT('',(4.76250000000188,95.885,78.3971));
#702=CARTESIAN_POINT('',(4.76250000000188,96.2025,78.3971));
#703=CARTESIAN_POINT('',(4.76250000000188,96.36125,78.3971));
#704=CARTESIAN_POINT('',(4.76250000000188,96.67875,78.3971));
#705=CARTESIAN_POINT('',(4.76250000000188,96.8375,78.3971));
#706=CARTESIAN_POINT('',(4.76250000000188,97.155,78.3971));
#707=CARTESIAN_POINT('',(4.76250000000188,97.31375,78.3971));
#708=CARTESIAN_POINT('',(4.76250000000188,97.63125,78.3971));
#709=CARTESIAN_POINT('',(4.76250000000188,97.79,78.3971));
#710=CARTESIAN_POINT('',(4.76250000000188,98.1075,78.3971));
#711=CARTESIAN_POINT('',(4.76250000000188,98.26625,78.3971));
#712=CARTESIAN_POINT('',(4.76250000000188,98.425,78.3971));
#713=B_SPLINE_CURVE_WITH_KNOTS('',3,(#647,#648,#649,#650,#651,#652,#653,#654,#655,#656,#657,
#658,#659,#660,#661,#662,#663,#664,#665,#666,#667,#668,#669,#670,#671,#672,#673,#674,#675,#676,
#677,#678,#679,#680,#681,#682,#683,#684,#685,#686,#687,#688,#689,#690,#691,#692,#693,#694,#695,
#696,#697,#698,#699,#700,#701,#702,#703,#704,#705,#706,#707,#708,#709,#710,#711,#712),
.UNSPECIFIED.,.F.,.F.,(4,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,4),(0.,
0.476249999999998,0.952499999999995,1.42874999999999,1.90499999999999,2.38124999999999,2.8575,
3.33375,3.80999999999999,4.28624999999999,4.76249999999999,5.23875,5.715,6.19125,
6.66749999999999,7.14374999999999,7.62,8.09625,8.5725,9.04874999999999,9.52499999999999,
10.00125,10.4775,10.95375,11.43,11.90625,12.3825,12.85875,13.335,13.81125,14.2875,14.76375,
15.24),.UNSPECIFIED.);
#714=EDGE_CURVE('BSEAM313',#645,#114,#713,.T.);
#715=ORIENTED_EDGE('',*,*,#646,.F.);
#716=ORIENTED_EDGE('',*,*,#115,.T.);
#717=ORIENTED_EDGE('',*,*,#714,.T.);
#718=ORIENTED_EDGE('',*,*,#714,.F.);
#719=EDGE_LOOP('',(#715,#717,#716,#718));
#720=FACE_BOUND('',#719,.T.);
#721=ADVANCED_FACE('F313',(#720),#638,.F.);
#722=CARTESIAN_POINT('',(4.76250000000188,83.185,76.2));
#723=DIRECTION('',(0.,1.,0.));
#724=DIRECTION('',(0.,0.,1.));
#725=AXIS2_PLACEMENT_3D('',#722,#723,#724);
#726=PLANE('',#725);
#727=ORIENTED_EDGE('',*,*,#646,.T.);
#728=EDGE_LOOP('',(#727));
#729=FACE_BOUND('',#728,.T.);
#730=ADVANCED_FACE('F318',(#729),#726,.T.);
#731=CARTESIAN_POINT('',(4.76250000000376,83.185,152.4));
#732=DIRECTION('',(0.,1.,0.));
#733=DIRECTION('',(0.,0.,1.));
#734=AXIS2_PLACEMENT_3D('',#731,#732,#733);
#735=CYLINDRICAL_SURFACE('',#734,2.1971);
#736=CARTESIAN_POINT('',(4.76250000000376,83.185,152.4));
#737=DIRECTION('',(0.,1.,0.));
#738=DIRECTION('',(0.,0.,1.));
#739=AXIS2_PLACEMENT_3D('',#736,#737,#738);
#740=CIRCLE('',#739,2.1971);
#741=CARTESIAN_POINT('',(4.76250000000376,83.185,154.5971));
#742=VERTEX_POINT('',#741);
#743=EDGE_CURVE('E122',#742,#742,#740,.T.);
#744=CARTESIAN_POINT('',(4.76250000000376,83.185,154.5971));
#745=CARTESIAN_POINT('',(4.76250000000376,83.34375,154.5971));
#746=CARTESIAN_POINT('',(4.76250000000376,83.5025,154.5971));
#747=CARTESIAN_POINT('',(4.76250000000376,83.82,154.5971));
#748=CARTESIAN_POINT('',(4.76250000000376,83.97875,154.5971));
#749=CARTESIAN_POINT('',(4.76250000000376,84.29625,154.5971));
#750=CARTESIAN_POINT('',(4.76250000000376,84.455,154.5971));
#751=CARTESIAN_POINT('',(4.76250000000376,84.7725,154.5971));
#752=CARTESIAN_POINT('',(4.76250000000376,84.93125,154.5971));
#753=CARTESIAN_POINT('',(4.76250000000376,85.24875,154.5971));
#754=CARTESIAN_POINT('',(4.76250000000376,85.4075,154.5971));
#755=CARTESIAN_POINT('',(4.76250000000376,85.725,154.5971));
#756=CARTESIAN_POINT('',(4.76250000000376,85.88375,154.5971));
#757=CARTESIAN_POINT('',(4.76250000000376,86.20125,154.5971));
#758=CARTESIAN_POINT('',(4.76250000000376,86.36,154.5971));
#759=CARTESIAN_POINT('',(4.76250000000376,86.6775,154.5971));
#760=CARTESIAN_POINT('',(4.76250000000376,86.83625,154.5971));
#761=CARTESIAN_POINT('',(4.76250000000376,87.15375,154.5971));
#762=CARTESIAN_POINT('',(4.76250000000376,87.3125,154.5971));
#763=CARTESIAN_POINT('',(4.76250000000376,87.63,154.5971));
#764=CARTESIAN_POINT('',(4.76250000000376,87.78875,154.5971));
#765=CARTESIAN_POINT('',(4.76250000000376,88.10625,154.5971));
#766=CARTESIAN_POINT('',(4.76250000000376,88.265,154.5971));
#767=CARTESIAN_POINT('',(4.76250000000376,88.5825,154.5971));
#768=CARTESIAN_POINT('',(4.76250000000376,88.74125,154.5971));
#769=CARTESIAN_POINT('',(4.76250000000376,89.05875,154.5971));
#770=CARTESIAN_POINT('',(4.76250000000376,89.2175,154.5971));
#771=CARTESIAN_POINT('',(4.76250000000376,89.535,154.5971));
#772=CARTESIAN_POINT('',(4.76250000000376,89.69375,154.5971));
#773=CARTESIAN_POINT('',(4.76250000000376,90.01125,154.5971));
#774=CARTESIAN_POINT('',(4.76250000000376,90.17,154.5971));
#775=CARTESIAN_POINT('',(4.76250000000376,90.4875,154.5971));
#776=CARTESIAN_POINT('',(4.76250000000376,90.64625,154.5971));
#777=CARTESIAN_POINT('',(4.76250000000376,90.96375,154.5971));
#778=CARTESIAN_POINT('',(4.76250000000376,91.1225,154.5971));
#779=CARTESIAN_POINT('',(4.76250000000376,91.44,154.5971));
#780=CARTESIAN_POINT('',(4.76250000000376,91.59875,154.5971));
#781=CARTESIAN_POINT('',(4.76250000000376,91.91625,154.5971));
#782=CARTESIAN_POINT('',(4.76250000000376,92.075,154.5971));
#783=CARTESIAN_POINT('',(4.76250000000376,92.3925,154.5971));
#784=CARTESIAN_POINT('',(4.76250000000376,92.55125,154.5971));
#785=CARTESIAN_POINT('',(4.76250000000376,92.86875,154.5971));
#786=CARTESIAN_POINT('',(4.76250000000376,93.0275,154.5971));
#787=CARTESIAN_POINT('',(4.76250000000376,93.345,154.5971));
#788=CARTESIAN_POINT('',(4.76250000000376,93.50375,154.5971));
#789=CARTESIAN_POINT('',(4.76250000000376,93.82125,154.5971));
#790=CARTESIAN_POINT('',(4.76250000000376,93.98,154.5971));
#791=CARTESIAN_POINT('',(4.76250000000376,94.2975,154.5971));
#792=CARTESIAN_POINT('',(4.76250000000376,94.45625,154.5971));
#793=CARTESIAN_POINT('',(4.76250000000376,94.77375,154.5971));
#794=CARTESIAN_POINT('',(4.76250000000376,94.9325,154.5971));
#795=CARTESIAN_POINT('',(4.76250000000376,95.25,154.5971));
#796=CARTESIAN_POINT('',(4.76250000000376,95.40875,154.5971));
#797=CARTESIAN_POINT('',(4.76250000000376,95.72625,154.5971));
#798=CARTESIAN_POINT('',(4.76250000000376,95.885,154.5971));
#799=CARTESIAN_POINT('',(4.76250000000376,96.2025,154.5971));
#800=CARTESIAN_POINT('',(4.76250000000376,96.36125,154.5971));
#801=CARTESIAN_POINT('',(4.76250000000376,96.67875,154.5971));
#802=CARTESIAN_POINT('',(4.76250000000376,96.8375,154.5971));
#803=CARTESIAN_POINT('',(4.76250000000376,97.155,154.5971));
#804=CARTESIAN_POINT('',(4.76250000000376,97.31375,154.5971));
#805=CARTESIAN_POINT('',(4.76250000000376,97.63125,154.5971));
#806=CARTESIAN_POINT('',(4.76250000000376,97.79,154.5971));
#807=CARTESIAN_POINT('',(4.76250000000376,98.1075,154.5971));
#808=CARTESIAN_POINT('',(4.76250000000376,98.26625,154.5971));
#809=CARTESIAN_POINT('',(4.76250000000376,98.425,154.5971));
#810=B_SPLINE_CURVE_WITH_KNOTS('',3,(#744,#745,#746,#747,#748,#749,#750,#751,#752,#753,#754,
#755,#756,#757,#758,#759,#760,#761,#762,#763,#764,#765,#766,#767,#768,#769,#770,#771,#772,#773,
#774,#775,#776,#777,#778,#779,#780,#781,#782,#783,#784,#785,#786,#787,#788,#789,#790,#791,#792,
#793,#794,#795,#796,#797,#798,#799,#800,#801,#802,#803,#804,#805,#806,#807,#808,#809),
.UNSPECIFIED.,.F.,.F.,(4,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,4),(0.,
0.476249999999998,0.952499999999995,1.42874999999999,1.90499999999999,2.38124999999999,2.8575,
3.33375,3.80999999999999,4.28624999999999,4.76249999999999,5.23875,5.715,6.19125,
6.66749999999999,7.14374999999999,7.62,8.09625,8.5725,9.04874999999999,9.52499999999999,
10.00125,10.4775,10.95375,11.43,11.90625,12.3825,12.85875,13.335,13.81125,14.2875,14.76375,
15.24),.UNSPECIFIED.);
#811=EDGE_CURVE('BSEAM321',#742,#103,#810,.T.);
#812=ORIENTED_EDGE('',*,*,#743,.F.);
#813=ORIENTED_EDGE('',*,*,#104,.T.);
#814=ORIENTED_EDGE('',*,*,#811,.T.);
#815=ORIENTED_EDGE('',*,*,#811,.F.);
#816=EDGE_LOOP('',(#812,#814,#813,#815));
#817=FACE_BOUND('',#816,.T.);
#818=ADVANCED_FACE('F321',(#817),#735,.F.);
#819=CARTESIAN_POINT('',(4.76250000000376,83.185,152.4));
#820=DIRECTION('',(0.,1.,0.));
#821=DIRECTION('',(0.,0.,1.));
#822=AXIS2_PLACEMENT_3D('',#819,#820,#821);
#823=PLANE('',#822);
#824=ORIENTED_EDGE('',*,*,#743,.T.);
#825=EDGE_LOOP('',(#824));
#826=FACE_BOUND('',#825,.T.);
#827=ADVANCED_FACE('F298',(#826),#823,.T.);
#828=CARTESIAN_POINT('',(4.7625,0.,149.86));
#829=DIRECTION('',(0.,0.,1.));
#830=DIRECTION('',(1.,0.,0.));
#831=AXIS2_PLACEMENT_3D('',#828,#829,#830);
#832=CYLINDRICAL_SURFACE('',#831,2.1971);
#833=CARTESIAN_POINT('',(4.7625,0.,149.86));
#834=DIRECTION('',(0.,0.,1.));
#835=DIRECTION('',(1.,0.,0.));
#836=AXIS2_PLACEMENT_3D('',#833,#834,#835);
#837=CIRCLE('',#836,2.1971);
#838=CARTESIAN_POINT('',(6.9596,0.,149.86));
#839=VERTEX_POINT('',#838);
#840=EDGE_CURVE('E123',#839,#839,#837,.T.);
#841=CARTESIAN_POINT('',(6.9596,0.,149.86));
#842=CARTESIAN_POINT('',(6.9596,0.,150.01875));
#843=CARTESIAN_POINT('',(6.9596,0.,150.1775));
#844=CARTESIAN_POINT('',(6.9596,0.,150.495));
#845=CARTESIAN_POINT('',(6.9596,0.,150.65375));
#846=CARTESIAN_POINT('',(6.9596,0.,150.97125));
#847=CARTESIAN_POINT('',(6.9596,0.,151.13));
#848=CARTESIAN_POINT('',(6.9596,0.,151.4475));
#849=CARTESIAN_POINT('',(6.9596,0.,151.60625));
#850=CARTESIAN_POINT('',(6.9596,0.,151.92375));
#851=CARTESIAN_POINT('',(6.9596,0.,152.0825));
#852=CARTESIAN_POINT('',(6.9596,0.,152.4));
#853=CARTESIAN_POINT('',(6.9596,0.,152.55875));
#854=CARTESIAN_POINT('',(6.9596,0.,152.87625));
#855=CARTESIAN_POINT('',(6.9596,0.,153.035));
#856=CARTESIAN_POINT('',(6.9596,0.,153.3525));
#857=CARTESIAN_POINT('',(6.9596,0.,153.51125));
#858=CARTESIAN_POINT('',(6.9596,0.,153.82875));
#859=CARTESIAN_POINT('',(6.9596,0.,153.9875));
#860=CARTESIAN_POINT('',(6.9596,0.,154.305));
#861=CARTESIAN_POINT('',(6.9596,0.,154.46375));
#862=CARTESIAN_POINT('',(6.9596,0.,154.78125));
#863=CARTESIAN_POINT('',(6.9596,0.,154.94));
#864=CARTESIAN_POINT('',(6.9596,0.,155.2575));
#865=CARTESIAN_POINT('',(6.9596,0.,155.41625));
#866=CARTESIAN_POINT('',(6.9596,0.,155.73375));
#867=CARTESIAN_POINT('',(6.9596,0.,155.8925));
#868=CARTESIAN_POINT('',(6.9596,0.,156.21));
#869=CARTESIAN_POINT('',(6.9596,0.,156.36875));
#870=CARTESIAN_POINT('',(6.9596,0.,156.68625));
#871=CARTESIAN_POINT('',(6.9596,0.,156.845));
#872=CARTESIAN_POINT('',(6.9596,0.,157.1625));
#873=CARTESIAN_POINT('',(6.9596,0.,157.32125));
#874=CARTESIAN_POINT('',(6.9596,0.,157.63875));
#875=CARTESIAN_POINT('',(6.9596,0.,157.7975));
#876=CARTESIAN_POINT('',(6.9596,0.,158.115));
#877=CARTESIAN_POINT('',(6.9596,0.,158.27375));
#878=CARTESIAN_POINT('',(6.9596,0.,158.59125));
#879=CARTESIAN_POINT('',(6.9596,0.,158.75));
#880=CARTESIAN_POINT('',(6.9596,0.,159.0675));
#881=CARTESIAN_POINT('',(6.9596,0.,159.22625));
#882=CARTESIAN_POINT('',(6.9596,0.,159.54375));
#883=CARTESIAN_POINT('',(6.9596,0.,159.7025));
#884=CARTESIAN_POINT('',(6.9596,0.,160.02));
#885=CARTESIAN_POINT('',(6.9596,0.,160.17875));
#886=CARTESIAN_POINT('',(6.9596,0.,160.49625));
#887=CARTESIAN_POINT('',(6.9596,0.,160.655));
#888=CARTESIAN_POINT('',(6.9596,0.,160.9725));
#889=CARTESIAN_POINT('',(6.9596,0.,161.13125));
#890=CARTESIAN_POINT('',(6.9596,0.,161.44875));
#891=CARTESIAN_POINT('',(6.9596,0.,161.6075));
#892=CARTESIAN_POINT('',(6.9596,0.,161.925));
#893=CARTESIAN_POINT('',(6.9596,0.,162.08375));
#894=CARTESIAN_POINT('',(6.9596,0.,162.40125));
#895=CARTESIAN_POINT('',(6.9596,0.,162.56));
#896=CARTESIAN_POINT('',(6.9596,0.,162.8775));
#897=CARTESIAN_POINT('',(6.9596,0.,163.03625));
#898=CARTESIAN_POINT('',(6.9596,0.,163.35375));
#899=CARTESIAN_POINT('',(6.9596,0.,163.5125));
#900=CARTESIAN_POINT('',(6.9596,0.,163.83));
#901=CARTESIAN_POINT('',(6.9596,0.,163.98875));
#902=CARTESIAN_POINT('',(6.9596,0.,164.30625));
#903=CARTESIAN_POINT('',(6.9596,0.,164.465));
#904=CARTESIAN_POINT('',(6.9596,0.,164.7825));
#905=CARTESIAN_POINT('',(6.9596,0.,164.94125));
#906=CARTESIAN_POINT('',(6.9596,0.,165.1));
#907=B_SPLINE_CURVE_WITH_KNOTS('',3,(#841,#842,#843,#844,#845,#846,#847,#848,#849,#850,#851,
#852,#853,#854,#855,#856,#857,#858,#859,#860,#861,#862,#863,#864,#865,#866,#867,#868,#869,#870,
#871,#872,#873,#874,#875,#876,#877,#878,#879,#880,#881,#882,#883,#884,#885,#886,#887,#888,#889,
#890,#891,#892,#893,#894,#895,#896,#897,#898,#899,#900,#901,#902,#903,#904,#905,#906),
.UNSPECIFIED.,.F.,.F.,(4,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,4),(0.,
0.476249999999984,0.952499999999995,1.42874999999998,1.90499999999999,2.38124999999997,
2.85749999999998,3.33375,3.80999999999998,4.28624999999999,4.76249999999998,5.23874999999999,
5.715,6.19124999999998,6.66749999999999,7.14374999999998,7.61999999999999,8.09625,
8.57249999999998,9.04874999999999,9.52499999999998,10.00125,10.4775,10.95375,11.43,11.90625,
12.3825,12.85875,13.335,13.81125,14.2875,14.76375,15.24),.UNSPECIFIED.);
#908=EDGE_CURVE('BSEAM294',#839,#211,#907,.T.);
#909=ORIENTED_EDGE('',*,*,#840,.F.);
#910=ORIENTED_EDGE('',*,*,#212,.T.);
#911=ORIENTED_EDGE('',*,*,#908,.T.);
#912=ORIENTED_EDGE('',*,*,#908,.F.);
#913=EDGE_LOOP('',(#909,#911,#910,#912));
#914=FACE_BOUND('',#913,.T.);
#915=ADVANCED_FACE('F294',(#914),#832,.F.);
#916=CARTESIAN_POINT('',(4.7625,0.,149.86));
#917=DIRECTION('',(0.,0.,1.));
#918=DIRECTION('',(1.,0.,0.));
#919=AXIS2_PLACEMENT_3D('',#916,#917,#918);
#920=PLANE('',#919);
#921=ORIENTED_EDGE('',*,*,#840,.T.);
#922=EDGE_LOOP('',(#921));
#923=FACE_BOUND('',#922,.T.);
#924=ADVANCED_FACE('F284',(#923),#920,.T.);
#925=CARTESIAN_POINT('',(4.76249999999974,76.2,149.86));
#926=DIRECTION('',(0.,0.,1.));
#927=DIRECTION('',(1.,0.,0.));
#928=AXIS2_PLACEMENT_3D('',#925,#926,#927);
#929=CYLINDRICAL_SURFACE('',#928,2.1971);
#930=CARTESIAN_POINT('',(4.76249999999974,76.2,149.86));
#931=DIRECTION('',(0.,0.,1.));
#932=DIRECTION('',(1.,0.,0.));
#933=AXIS2_PLACEMENT_3D('',#930,#931,#932);
#934=CIRCLE('',#933,2.1971);
#935=CARTESIAN_POINT('',(6.95959999999974,76.2,149.86));
#936=VERTEX_POINT('',#935);
#937=EDGE_CURVE('E146',#936,#936,#934,.T.);
#938=CARTESIAN_POINT('',(6.95959999999974,76.2,149.86));
#939=CARTESIAN_POINT('',(6.95959999999974,76.2,150.01875));
#940=CARTESIAN_POINT('',(6.95959999999974,76.2,150.1775));
#941=CARTESIAN_POINT('',(6.95959999999974,76.2,150.495));
#942=CARTESIAN_POINT('',(6.95959999999974,76.2,150.65375));
#943=CARTESIAN_POINT('',(6.95959999999974,76.2,150.97125));
#944=CARTESIAN_POINT('',(6.95959999999974,76.2,151.13));
#945=CARTESIAN_POINT('',(6.95959999999974,76.2,151.4475));
#946=CARTESIAN_POINT('',(6.95959999999974,76.2,151.60625));
#947=CARTESIAN_POINT('',(6.95959999999974,76.2,151.92375));
#948=CARTESIAN_POINT('',(6.95959999999974,76.2,152.0825));
#949=CARTESIAN_POINT('',(6.95959999999974,76.2,152.4));
#950=CARTESIAN_POINT('',(6.95959999999974,76.2,152.55875));
#951=CARTESIAN_POINT('',(6.95959999999974,76.2,152.87625));
#952=CARTESIAN_POINT('',(6.95959999999974,76.2,153.035));
#953=CARTESIAN_POINT('',(6.95959999999974,76.2,153.3525));
#954=CARTESIAN_POINT('',(6.95959999999974,76.2,153.51125));
#955=CARTESIAN_POINT('',(6.95959999999974,76.2,153.82875));
#956=CARTESIAN_POINT('',(6.95959999999974,76.2,153.9875));
#957=CARTESIAN_POINT('',(6.95959999999974,76.2,154.305));
#958=CARTESIAN_POINT('',(6.95959999999974,76.2,154.46375));
#959=CARTESIAN_POINT('',(6.95959999999974,76.2,154.78125));
#960=CARTESIAN_POINT('',(6.95959999999974,76.2,154.94));
#961=CARTESIAN_POINT('',(6.95959999999974,76.2,155.2575));
#962=CARTESIAN_POINT('',(6.95959999999974,76.2,155.41625));
#963=CARTESIAN_POINT('',(6.95959999999974,76.2,155.73375));
#964=CARTESIAN_POINT('',(6.95959999999974,76.2,155.8925));
#965=CARTESIAN_POINT('',(6.95959999999974,76.2,156.21));
#966=CARTESIAN_POINT('',(6.95959999999974,76.2,156.36875));
#967=CARTESIAN_POINT('',(6.95959999999974,76.2,156.68625));
#968=CARTESIAN_POINT('',(6.95959999999974,76.2,156.845));
#969=CARTESIAN_POINT('',(6.95959999999974,76.2,157.1625));
#970=CARTESIAN_POINT('',(6.95959999999974,76.2,157.32125));
#971=CARTESIAN_POINT('',(6.95959999999974,76.2,157.63875));
#972=CARTESIAN_POINT('',(6.95959999999974,76.2,157.7975));
#973=CARTESIAN_POINT('',(6.95959999999974,76.2,158.115));
#974=CARTESIAN_POINT('',(6.95959999999974,76.2,158.27375));
#975=CARTESIAN_POINT('',(6.95959999999974,76.2,158.59125));
#976=CARTESIAN_POINT('',(6.95959999999974,76.2,158.75));
#977=CARTESIAN_POINT('',(6.95959999999974,76.2,159.0675));
#978=CARTESIAN_POINT('',(6.95959999999974,76.2,159.22625));
#979=CARTESIAN_POINT('',(6.95959999999974,76.2,159.54375));
#980=CARTESIAN_POINT('',(6.95959999999974,76.2,159.7025));
#981=CARTESIAN_POINT('',(6.95959999999974,76.2,160.02));
#982=CARTESIAN_POINT('',(6.95959999999974,76.2,160.17875));
#983=CARTESIAN_POINT('',(6.95959999999974,76.2,160.49625));
#984=CARTESIAN_POINT('',(6.95959999999974,76.2,160.655));
#985=CARTESIAN_POINT('',(6.95959999999974,76.2,160.9725));
#986=CARTESIAN_POINT('',(6.95959999999974,76.2,161.13125));
#987=CARTESIAN_POINT('',(6.95959999999974,76.2,161.44875));
#988=CARTESIAN_POINT('',(6.95959999999974,76.2,161.6075));
#989=CARTESIAN_POINT('',(6.95959999999974,76.2,161.925));
#990=CARTESIAN_POINT('',(6.95959999999974,76.2,162.08375));
#991=CARTESIAN_POINT('',(6.95959999999974,76.2,162.40125));
#992=CARTESIAN_POINT('',(6.95959999999974,76.2,162.56));
#993=CARTESIAN_POINT('',(6.95959999999974,76.2,162.8775));
#994=CARTESIAN_POINT('',(6.95959999999974,76.2,163.03625));
#995=CARTESIAN_POINT('',(6.95959999999974,76.2,163.35375));
#996=CARTESIAN_POINT('',(6.95959999999974,76.2,163.5125));
#997=CARTESIAN_POINT('',(6.95959999999974,76.2,163.83));
#998=CARTESIAN_POINT('',(6.95959999999974,76.2,163.98875));
#999=CARTESIAN_POINT('',(6.95959999999974,76.2,164.30625));
#1000=CARTESIAN_POINT('',(6.95959999999974,76.2,164.465));
#1001=CARTESIAN_POINT('',(6.95959999999974,76.2,164.7825));
#1002=CARTESIAN_POINT('',(6.95959999999974,76.2,164.94125));
#1003=CARTESIAN_POINT('',(6.95959999999974,76.2,165.1));
#1004=B_SPLINE_CURVE_WITH_KNOTS('',3,(#938,#939,#940,#941,#942,#943,#944,#945,#946,#947,#948,
#949,#950,#951,#952,#953,#954,#955,#956,#957,#958,#959,#960,#961,#962,#963,#964,#965,#966,#967,
#968,#969,#970,#971,#972,#973,#974,#975,#976,#977,#978,#979,#980,#981,#982,#983,#984,#985,#986,
#987,#988,#989,#990,#991,#992,#993,#994,#995,#996,#997,#998,#999,#1000,#1001,#1002,#1003),
.UNSPECIFIED.,.F.,.F.,(4,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,4),(0.,
0.476249999999984,0.952499999999995,1.42874999999998,1.90499999999999,2.38124999999997,
2.85749999999998,3.33375,3.80999999999998,4.28624999999999,4.76249999999998,5.23874999999999,
5.715,6.19124999999998,6.66749999999999,7.14374999999998,7.61999999999999,8.09625,
8.57249999999998,9.04874999999999,9.52499999999998,10.00125,10.4775,10.95375,11.43,11.90625,
12.3825,12.85875,13.335,13.81125,14.2875,14.76375,15.24),.UNSPECIFIED.);
#1005=EDGE_CURVE('BSEAM280',#936,#200,#1004,.T.);
#1006=ORIENTED_EDGE('',*,*,#937,.F.);
#1007=ORIENTED_EDGE('',*,*,#201,.T.);
#1008=ORIENTED_EDGE('',*,*,#1005,.T.);
#1009=ORIENTED_EDGE('',*,*,#1005,.F.);
#1010=EDGE_LOOP('',(#1006,#1008,#1007,#1009));
#1011=FACE_BOUND('',#1010,.T.);
#1012=ADVANCED_FACE('F280',(#1011),#929,.F.);
#1013=CARTESIAN_POINT('',(4.76249999999974,76.2,149.86));
#1014=DIRECTION('',(0.,0.,1.));
#1015=DIRECTION('',(1.,0.,0.));
#1016=AXIS2_PLACEMENT_3D('',#1013,#1014,#1015);
#1017=PLANE('',#1016);
#1018=ORIENTED_EDGE('',*,*,#937,.T.);
#1019=EDGE_LOOP('',(#1018));
#1020=FACE_BOUND('',#1019,.T.);
#1021=ADVANCED_FACE('F276',(#1020),#1017,.T.);
#1022=CARTESIAN_POINT('',(4.7625000000008,-76.2,149.86));
#1023=DIRECTION('',(0.,0.,1.));
#1024=DIRECTION('',(1.,0.,0.));
#1025=AXIS2_PLACEMENT_3D('',#1022,#1023,#1024);
#1026=CYLINDRICAL_SURFACE('',#1025,2.1971);
#1027=CARTESIAN_POINT('',(4.7625000000008,-76.2,149.86));
#1028=DIRECTION('',(0.,0.,1.));
#1029=DIRECTION('',(1.,0.,0.));
#1030=AXIS2_PLACEMENT_3D('',#1027,#1028,#1029);
#1031=CIRCLE('',#1030,2.1971);
#1032=CARTESIAN_POINT('',(6.9596000000008,-76.2,149.86));
#1033=VERTEX_POINT('',#1032);
#1034=EDGE_CURVE('E152',#1033,#1033,#1031,.T.);
#1035=CARTESIAN_POINT('',(6.9596000000008,-76.2,149.86));
#1036=CARTESIAN_POINT('',(6.9596000000008,-76.2,150.01875));
#1037=CARTESIAN_POINT('',(6.9596000000008,-76.2,150.1775));
#1038=CARTESIAN_POINT('',(6.9596000000008,-76.2,150.495));
#1039=CARTESIAN_POINT('',(6.9596000000008,-76.2,150.65375));
#1040=CARTESIAN_POINT('',(6.9596000000008,-76.2,150.97125));
#1041=CARTESIAN_POINT('',(6.9596000000008,-76.2,151.13));
#1042=CARTESIAN_POINT('',(6.9596000000008,-76.2,151.4475));
#1043=CARTESIAN_POINT('',(6.9596000000008,-76.2,151.60625));
#1044=CARTESIAN_POINT('',(6.9596000000008,-76.2,151.92375));
#1045=CARTESIAN_POINT('',(6.9596000000008,-76.2,152.0825));
#1046=CARTESIAN_POINT('',(6.9596000000008,-76.2,152.4));
#1047=CARTESIAN_POINT('',(6.9596000000008,-76.2,152.55875));
#1048=CARTESIAN_POINT('',(6.9596000000008,-76.2,152.87625));
#1049=CARTESIAN_POINT('',(6.9596000000008,-76.2,153.035));
#1050=CARTESIAN_POINT('',(6.9596000000008,-76.2,153.3525));
#1051=CARTESIAN_POINT('',(6.9596000000008,-76.2,153.51125));
#1052=CARTESIAN_POINT('',(6.9596000000008,-76.2,153.82875));
#1053=CARTESIAN_POINT('',(6.9596000000008,-76.2,153.9875));
#1054=CARTESIAN_POINT('',(6.9596000000008,-76.2,154.305));
#1055=CARTESIAN_POINT('',(6.9596000000008,-76.2,154.46375));
#1056=CARTESIAN_POINT('',(6.9596000000008,-76.2,154.78125));
#1057=CARTESIAN_POINT('',(6.9596000000008,-76.2,154.94));
#1058=CARTESIAN_POINT('',(6.9596000000008,-76.2,155.2575));
#1059=CARTESIAN_POINT('',(6.9596000000008,-76.2,155.41625));
#1060=CARTESIAN_POINT('',(6.9596000000008,-76.2,155.73375));
#1061=CARTESIAN_POINT('',(6.9596000000008,-76.2,155.8925));
#1062=CARTESIAN_POINT('',(6.9596000000008,-76.2,156.21));
#1063=CARTESIAN_POINT('',(6.9596000000008,-76.2,156.36875));
#1064=CARTESIAN_POINT('',(6.9596000000008,-76.2,156.68625));
#1065=CARTESIAN_POINT('',(6.9596000000008,-76.2,156.845));
#1066=CARTESIAN_POINT('',(6.9596000000008,-76.2,157.1625));
#1067=CARTESIAN_POINT('',(6.9596000000008,-76.2,157.32125));
#1068=CARTESIAN_POINT('',(6.9596000000008,-76.2,157.63875));
#1069=CARTESIAN_POINT('',(6.9596000000008,-76.2,157.7975));
#1070=CARTESIAN_POINT('',(6.9596000000008,-76.2,158.115));
#1071=CARTESIAN_POINT('',(6.9596000000008,-76.2,158.27375));
#1072=CARTESIAN_POINT('',(6.9596000000008,-76.2,158.59125));
#1073=CARTESIAN_POINT('',(6.9596000000008,-76.2,158.75));
#1074=CARTESIAN_POINT('',(6.9596000000008,-76.2,159.0675));
#1075=CARTESIAN_POINT('',(6.9596000000008,-76.2,159.22625));
#1076=CARTESIAN_POINT('',(6.9596000000008,-76.2,159.54375));
#1077=CARTESIAN_POINT('',(6.9596000000008,-76.2,159.7025));
#1078=CARTESIAN_POINT('',(6.9596000000008,-76.2,160.02));
#1079=CARTESIAN_POINT('',(6.9596000000008,-76.2,160.17875));
#1080=CARTESIAN_POINT('',(6.9596000000008,-76.2,160.49625));
#1081=CARTESIAN_POINT('',(6.9596000000008,-76.2,160.655));
#1082=CARTESIAN_POINT('',(6.9596000000008,-76.2,160.9725));
#1083=CARTESIAN_POINT('',(6.9596000000008,-76.2,161.13125));
#1084=CARTESIAN_POINT('',(6.9596000000008,-76.2,161.44875));
#1085=CARTESIAN_POINT('',(6.9596000000008,-76.2,161.6075));
#1086=CARTESIAN_POINT('',(6.9596000000008,-76.2,161.925));
#1087=CARTESIAN_POINT('',(6.9596000000008,-76.2,162.08375));
#1088=CARTESIAN_POINT('',(6.9596000000008,-76.2,162.40125));
#1089=CARTESIAN_POINT('',(6.9596000000008,-76.2,162.56));
#1090=CARTESIAN_POINT('',(6.9596000000008,-76.2,162.8775));
#1091=CARTESIAN_POINT('',(6.9596000000008,-76.2,163.03625));
#1092=CARTESIAN_POINT('',(6.9596000000008,-76.2,163.35375));
#1093=CARTESIAN_POINT('',(6.9596000000008,-76.2,163.5125));
#1094=CARTESIAN_POINT('',(6.9596000000008,-76.2,163.83));
#1095=CARTESIAN_POINT('',(6.9596000000008,-76.2,163.98875));
#1096=CARTESIAN_POINT('',(6.9596000000008,-76.2,164.30625));
#1097=CARTESIAN_POINT('',(6.9596000000008,-76.2,164.465));
#1098=CARTESIAN_POINT('',(6.9596000000008,-76.2,164.7825));
#1099=CARTESIAN_POINT('',(6.9596000000008,-76.2,164.94125));
#1100=CARTESIAN_POINT('',(6.9596000000008,-76.2,165.1));
#1101=B_SPLINE_CURVE_WITH_KNOTS('',3,(#1035,#1036,#1037,#1038,#1039,#1040,#1041,#1042,#1043,
#1044,#1045,#1046,#1047,#1048,#1049,#1050,#1051,#1052,#1053,#1054,#1055,#1056,#1057,#1058,#1059,
#1060,#1061,#1062,#1063,#1064,#1065,#1066,#1067,#1068,#1069,#1070,#1071,#1072,#1073,#1074,#1075,
#1076,#1077,#1078,#1079,#1080,#1081,#1082,#1083,#1084,#1085,#1086,#1087,#1088,#1089,#1090,#1091,
#1092,#1093,#1094,#1095,#1096,#1097,#1098,#1099,#1100),.UNSPECIFIED.,.F.,.F.,(4,2,2,2,2,2,2,2,2,
2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,4),(0.,0.476249999999984,0.952499999999995,
1.42874999999998,1.90499999999999,2.38124999999997,2.85749999999998,3.33375,3.80999999999998,
4.28624999999999,4.76249999999998,5.23874999999999,5.715,6.19124999999998,6.66749999999999,
7.14374999999998,7.61999999999999,8.09625,8.57249999999998,9.04874999999999,9.52499999999998,
10.00125,10.4775,10.95375,11.43,11.90625,12.3825,12.85875,13.335,13.81125,14.2875,14.76375,
15.24),.UNSPECIFIED.);
#1102=EDGE_CURVE('BSEAM279',#1033,#189,#1101,.T.);
#1103=ORIENTED_EDGE('',*,*,#1034,.F.);
#1104=ORIENTED_EDGE('',*,*,#190,.T.);
#1105=ORIENTED_EDGE('',*,*,#1102,.T.);
#1106=ORIENTED_EDGE('',*,*,#1102,.F.);
#1107=EDGE_LOOP('',(#1103,#1105,#1104,#1106));
#1108=FACE_BOUND('',#1107,.T.);
#1109=ADVANCED_FACE('F279',(#1108),#1026,.F.);
#1110=CARTESIAN_POINT('',(4.7625000000008,-76.2,149.86));
#1111=DIRECTION('',(0.,0.,1.));
#1112=DIRECTION('',(1.,0.,0.));
#1113=AXIS2_PLACEMENT_3D('',#1110,#1111,#1112);
#1114=PLANE('',#1113);
#1115=ORIENTED_EDGE('',*,*,#1034,.T.);
#1116=EDGE_LOOP('',(#1115));
#1117=FACE_BOUND('',#1116,.T.);
#1118=ADVANCED_FACE('F274',(#1117),#1114,.T.);
#1119=CARTESIAN_POINT('',(4.7625,-83.185,0.));
#1120=DIRECTION('',(0.,-1.,0.));
#1121=DIRECTION('',(0.,0.,-1.));
#1122=AXIS2_PLACEMENT_3D('',#1119,#1120,#1121);
#1123=CYLINDRICAL_SURFACE('',#1122,2.1971);
#1124=CARTESIAN_POINT('',(4.7625,-83.185,0.));
#1125=DIRECTION('',(0.,-1.,0.));
#1126=DIRECTION('',(0.,0.,-1.));
#1127=AXIS2_PLACEMENT_3D('',#1124,#1125,#1126);
#1128=CIRCLE('',#1127,2.1971);
#1129=CARTESIAN_POINT('',(4.7625,-83.185,-2.1971));
#1130=VERTEX_POINT('',#1129);
#1131=EDGE_CURVE('E153',#1130,#1130,#1128,.T.);
#1132=CARTESIAN_POINT('',(4.7625,-83.185,-2.1971));
#1133=CARTESIAN_POINT('',(4.7625,-83.34375,-2.1971));
#1134=CARTESIAN_POINT('',(4.7625,-83.5025,-2.1971));
#1135=CARTESIAN_POINT('',(4.7625,-83.82,-2.1971));
#1136=CARTESIAN_POINT('',(4.7625,-83.97875,-2.1971));
#1137=CARTESIAN_POINT('',(4.7625,-84.29625,-2.1971));
#1138=CARTESIAN_POINT('',(4.7625,-84.455,-2.1971));
#1139=CARTESIAN_POINT('',(4.7625,-84.7725,-2.1971));
#1140=CARTESIAN_POINT('',(4.7625,-84.93125,-2.1971));
#1141=CARTESIAN_POINT('',(4.7625,-85.24875,-2.1971));
#1142=CARTESIAN_POINT('',(4.7625,-85.4075,-2.1971));
#1143=CARTESIAN_POINT('',(4.7625,-85.725,-2.1971));
#1144=CARTESIAN_POINT('',(4.7625,-85.88375,-2.1971));
#1145=CARTESIAN_POINT('',(4.7625,-86.20125,-2.1971));
#1146=CARTESIAN_POINT('',(4.7625,-86.36,-2.1971));
#1147=CARTESIAN_POINT('',(4.7625,-86.6775,-2.1971));
#1148=CARTESIAN_POINT('',(4.7625,-86.83625,-2.1971));
#1149=CARTESIAN_POINT('',(4.7625,-87.15375,-2.1971));
#1150=CARTESIAN_POINT('',(4.7625,-87.3125,-2.1971));
#1151=CARTESIAN_POINT('',(4.7625,-87.63,-2.1971));
#1152=CARTESIAN_POINT('',(4.7625,-87.78875,-2.1971));
#1153=CARTESIAN_POINT('',(4.7625,-88.10625,-2.1971));
#1154=CARTESIAN_POINT('',(4.7625,-88.265,-2.1971));
#1155=CARTESIAN_POINT('',(4.7625,-88.5825,-2.1971));
#1156=CARTESIAN_POINT('',(4.7625,-88.74125,-2.1971));
#1157=CARTESIAN_POINT('',(4.7625,-89.05875,-2.1971));
#1158=CARTESIAN_POINT('',(4.7625,-89.2175,-2.1971));
#1159=CARTESIAN_POINT('',(4.7625,-89.535,-2.1971));
#1160=CARTESIAN_POINT('',(4.7625,-89.69375,-2.1971));
#1161=CARTESIAN_POINT('',(4.7625,-90.01125,-2.1971));
#1162=CARTESIAN_POINT('',(4.7625,-90.17,-2.1971));
#1163=CARTESIAN_POINT('',(4.7625,-90.4875,-2.1971));
#1164=CARTESIAN_POINT('',(4.7625,-90.64625,-2.1971));
#1165=CARTESIAN_POINT('',(4.7625,-90.96375,-2.1971));
#1166=CARTESIAN_POINT('',(4.7625,-91.1225,-2.1971));
#1167=CARTESIAN_POINT('',(4.7625,-91.44,-2.1971));
#1168=CARTESIAN_POINT('',(4.7625,-91.59875,-2.1971));
#1169=CARTESIAN_POINT('',(4.7625,-91.91625,-2.1971));
#1170=CARTESIAN_POINT('',(4.7625,-92.075,-2.1971));
#1171=CARTESIAN_POINT('',(4.7625,-92.3925,-2.1971));
#1172=CARTESIAN_POINT('',(4.7625,-92.55125,-2.1971));
#1173=CARTESIAN_POINT('',(4.7625,-92.86875,-2.1971));
#1174=CARTESIAN_POINT('',(4.7625,-93.0275,-2.1971));
#1175=CARTESIAN_POINT('',(4.7625,-93.345,-2.1971));
#1176=CARTESIAN_POINT('',(4.7625,-93.50375,-2.1971));
#1177=CARTESIAN_POINT('',(4.7625,-93.82125,-2.1971));
#1178=CARTESIAN_POINT('',(4.7625,-93.98,-2.1971));
#1179=CARTESIAN_POINT('',(4.7625,-94.2975,-2.1971));
#1180=CARTESIAN_POINT('',(4.7625,-94.45625,-2.1971));
#1181=CARTESIAN_POINT('',(4.7625,-94.77375,-2.1971));
#1182=CARTESIAN_POINT('',(4.7625,-94.9325,-2.1971));
#1183=CARTESIAN_POINT('',(4.7625,-95.25,-2.1971));
#1184=CARTESIAN_POINT('',(4.7625,-95.40875,-2.1971));
#1185=CARTESIAN_POINT('',(4.7625,-95.72625,-2.1971));
#1186=CARTESIAN_POINT('',(4.7625,-95.885,-2.1971));
#1187=CARTESIAN_POINT('',(4.7625,-96.2025,-2.1971));
#1188=CARTESIAN_POINT('',(4.7625,-96.36125,-2.1971));
#1189=CARTESIAN_POINT('',(4.7625,-96.67875,-2.1971));
#1190=CARTESIAN_POINT('',(4.7625,-96.8375,-2.1971));
#1191=CARTESIAN_POINT('',(4.7625,-97.155,-2.1971));
#1192=CARTESIAN_POINT('',(4.7625,-97.31375,-2.1971));
#1193=CARTESIAN_POINT('',(4.7625,-97.63125,-2.1971));
#1194=CARTESIAN_POINT('',(4.7625,-97.79,-2.1971));
#1195=CARTESIAN_POINT('',(4.7625,-98.1075,-2.1971));
#1196=CARTESIAN_POINT('',(4.7625,-98.26625,-2.1971));
#1197=CARTESIAN_POINT('',(4.7625,-98.425,-2.1971));
#1198=B_SPLINE_CURVE_WITH_KNOTS('',3,(#1132,#1133,#1134,#1135,#1136,#1137,#1138,#1139,#1140,
#1141,#1142,#1143,#1144,#1145,#1146,#1147,#1148,#1149,#1150,#1151,#1152,#1153,#1154,#1155,#1156,
#1157,#1158,#1159,#1160,#1161,#1162,#1163,#1164,#1165,#1166,#1167,#1168,#1169,#1170,#1171,#1172,
#1173,#1174,#1175,#1176,#1177,#1178,#1179,#1180,#1181,#1182,#1183,#1184,#1185,#1186,#1187,#1188,
#1189,#1190,#1191,#1192,#1193,#1194,#1195,#1196,#1197),.UNSPECIFIED.,.F.,.F.,(4,2,2,2,2,2,2,2,2,
2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,4),(0.,0.476249999999998,0.952499999999995,
1.42874999999999,1.90499999999999,2.38124999999999,2.8575,3.33375,3.80999999999999,
4.28624999999999,4.76249999999999,5.23875,5.715,6.19125,6.66749999999999,7.14374999999999,7.62,
8.09625,8.5725,9.04874999999999,9.52499999999999,10.00125,10.4775,10.95375,11.43,11.90625,
12.3825,12.85875,13.335,13.81125,14.2875,14.76375,15.24),.UNSPECIFIED.);
#1199=EDGE_CURVE('BSEAM270',#1130,#297,#1198,.T.);
#1200=ORIENTED_EDGE('',*,*,#1131,.F.);
#1201=ORIENTED_EDGE('',*,*,#298,.T.);
#1202=ORIENTED_EDGE('',*,*,#1199,.T.);
#1203=ORIENTED_EDGE('',*,*,#1199,.F.);
#1204=EDGE_LOOP('',(#1200,#1202,#1201,#1203));
#1205=FACE_BOUND('',#1204,.T.);
#1206=ADVANCED_FACE('F270',(#1205),#1123,.F.);
#1207=CARTESIAN_POINT('',(4.7625,-83.185,0.));
#1208=DIRECTION('',(0.,-1.,0.));
#1209=DIRECTION('',(0.,0.,-1.));
#1210=AXIS2_PLACEMENT_3D('',#1207,#1208,#1209);
#1211=PLANE('',#1210);
#1212=ORIENTED_EDGE('',*,*,#1131,.T.);
#1213=EDGE_LOOP('',(#1212));
#1214=FACE_BOUND('',#1213,.T.);
#1215=ADVANCED_FACE('F248',(#1214),#1211,.T.);
#1216=CARTESIAN_POINT('',(4.76249999999974,-83.185,76.2));
#1217=DIRECTION('',(0.,-1.,0.));
#1218=DIRECTION('',(0.,0.,-1.));
#1219=AXIS2_PLACEMENT_3D('',#1216,#1217,#1218);
#1220=CYLINDRICAL_SURFACE('',#1219,2.1971);
#1221=CARTESIAN_POINT('',(4.76249999999974,-83.185,76.2));
#1222=DIRECTION('',(0.,-1.,0.));
#1223=DIRECTION('',(0.,0.,-1.));
#1224=AXIS2_PLACEMENT_3D('',#1221,#1222,#1223);
#1225=CIRCLE('',#1224,2.1971);
#1226=CARTESIAN_POINT('',(4.76249999999974,-83.185,74.0029));
#1227=VERTEX_POINT('',#1226);
#1228=EDGE_CURVE('E164',#1227,#1227,#1225,.T.);
#1229=CARTESIAN_POINT('',(4.76249999999974,-83.185,74.0029));
#1230=CARTESIAN_POINT('',(4.76249999999974,-83.34375,74.0029));
#1231=CARTESIAN_POINT('',(4.76249999999974,-83.5025,74.0029));
#1232=CARTESIAN_POINT('',(4.76249999999974,-83.82,74.0029));
#1233=CARTESIAN_POINT('',(4.76249999999974,-83.97875,74.0029));
#1234=CARTESIAN_POINT('',(4.76249999999974,-84.29625,74.0029));
#1235=CARTESIAN_POINT('',(4.76249999999974,-84.455,74.0029));
#1236=CARTESIAN_POINT('',(4.76249999999974,-84.7725,74.0029));
#1237=CARTESIAN_POINT('',(4.76249999999974,-84.93125,74.0029));
#1238=CARTESIAN_POINT('',(4.76249999999974,-85.24875,74.0029));
#1239=CARTESIAN_POINT('',(4.76249999999974,-85.4075,74.0029));
#1240=CARTESIAN_POINT('',(4.76249999999974,-85.725,74.0029));
#1241=CARTESIAN_POINT('',(4.76249999999974,-85.88375,74.0029));
#1242=CARTESIAN_POINT('',(4.76249999999974,-86.20125,74.0029));
#1243=CARTESIAN_POINT('',(4.76249999999974,-86.36,74.0029));
#1244=CARTESIAN_POINT('',(4.76249999999974,-86.6775,74.0029));
#1245=CARTESIAN_POINT('',(4.76249999999974,-86.83625,74.0029));
#1246=CARTESIAN_POINT('',(4.76249999999974,-87.15375,74.0029));
#1247=CARTESIAN_POINT('',(4.76249999999974,-87.3125,74.0029));
#1248=CARTESIAN_POINT('',(4.76249999999974,-87.63,74.0029));
#1249=CARTESIAN_POINT('',(4.76249999999974,-87.78875,74.0029));
#1250=CARTESIAN_POINT('',(4.76249999999974,-88.10625,74.0029));
#1251=CARTESIAN_POINT('',(4.76249999999974,-88.265,74.0029));
#1252=CARTESIAN_POINT('',(4.76249999999974,-88.5825,74.0029));
#1253=CARTESIAN_POINT('',(4.76249999999974,-88.74125,74.0029));
#1254=CARTESIAN_POINT('',(4.76249999999974,-89.05875,74.0029));
#1255=CARTESIAN_POINT('',(4.76249999999974,-89.2175,74.0029));
#1256=CARTESIAN_POINT('',(4.76249999999974,-89.535,74.0029));
#1257=CARTESIAN_POINT('',(4.76249999999974,-89.69375,74.0029));
#1258=CARTESIAN_POINT('',(4.76249999999974,-90.01125,74.0029));
#1259=CARTESIAN_POINT('',(4.76249999999974,-90.17,74.0029));
#1260=CARTESIAN_POINT('',(4.76249999999974,-90.4875,74.0029));
#1261=CARTESIAN_POINT('',(4.76249999999974,-90.64625,74.0029));
#1262=CARTESIAN_POINT('',(4.76249999999974,-90.96375,74.0029));
#1263=CARTESIAN_POINT('',(4.76249999999974,-91.1225,74.0029));
#1264=CARTESIAN_POINT('',(4.76249999999974,-91.44,74.0029));
#1265=CARTESIAN_POINT('',(4.76249999999974,-91.59875,74.0029));
#1266=CARTESIAN_POINT('',(4.76249999999974,-91.91625,74.0029));
#1267=CARTESIAN_POINT('',(4.76249999999974,-92.075,74.0029));
#1268=CARTESIAN_POINT('',(4.76249999999974,-92.3925,74.0029));
#1269=CARTESIAN_POINT('',(4.76249999999974,-92.55125,74.0029));
#1270=CARTESIAN_POINT('',(4.76249999999974,-92.86875,74.0029));
#1271=CARTESIAN_POINT('',(4.76249999999974,-93.0275,74.0029));
#1272=CARTESIAN_POINT('',(4.76249999999974,-93.345,74.0029));
#1273=CARTESIAN_POINT('',(4.76249999999974,-93.50375,74.0029));
#1274=CARTESIAN_POINT('',(4.76249999999974,-93.82125,74.0029));
#1275=CARTESIAN_POINT('',(4.76249999999974,-93.98,74.0029));
#1276=CARTESIAN_POINT('',(4.76249999999974,-94.2975,74.0029));
#1277=CARTESIAN_POINT('',(4.76249999999974,-94.45625,74.0029));
#1278=CARTESIAN_POINT('',(4.76249999999974,-94.77375,74.0029));
#1279=CARTESIAN_POINT('',(4.76249999999974,-94.9325,74.0029));
#1280=CARTESIAN_POINT('',(4.76249999999974,-95.25,74.0029));
#1281=CARTESIAN_POINT('',(4.76249999999974,-95.40875,74.0029));
#1282=CARTESIAN_POINT('',(4.76249999999974,-95.72625,74.0029));
#1283=CARTESIAN_POINT('',(4.76249999999974,-95.885,74.0029));
#1284=CARTESIAN_POINT('',(4.76249999999974,-96.2025,74.0029));
#1285=CARTESIAN_POINT('',(4.76249999999974,-96.36125,74.0029));
#1286=CARTESIAN_POINT('',(4.76249999999974,-96.67875,74.0029));
#1287=CARTESIAN_POINT('',(4.76249999999974,-96.8375,74.0029));
#1288=CARTESIAN_POINT('',(4.76249999999974,-97.155,74.0029));
#1289=CARTESIAN_POINT('',(4.76249999999974,-97.31375,74.0029));
#1290=CARTESIAN_POINT('',(4.76249999999974,-97.63125,74.0029));
#1291=CARTESIAN_POINT('',(4.76249999999974,-97.79,74.0029));
#1292=CARTESIAN_POINT('',(4.76249999999974,-98.1075,74.0029));
#1293=CARTESIAN_POINT('',(4.76249999999974,-98.26625,74.0029));
#1294=CARTESIAN_POINT('',(4.76249999999974,-98.425,74.0029));
#1295=B_SPLINE_CURVE_WITH_KNOTS('',3,(#1229,#1230,#1231,#1232,#1233,#1234,#1235,#1236,#1237,
#1238,#1239,#1240,#1241,#1242,#1243,#1244,#1245,#1246,#1247,#1248,#1249,#1250,#1251,#1252,#1253,
#1254,#1255,#1256,#1257,#1258,#1259,#1260,#1261,#1262,#1263,#1264,#1265,#1266,#1267,#1268,#1269,
#1270,#1271,#1272,#1273,#1274,#1275,#1276,#1277,#1278,#1279,#1280,#1281,#1282,#1283,#1284,#1285,
#1286,#1287,#1288,#1289,#1290,#1291,#1292,#1293,#1294),.UNSPECIFIED.,.F.,.F.,(4,2,2,2,2,2,2,2,2,
2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,4),(0.,0.476249999999998,0.952499999999995,
1.42874999999999,1.90499999999999,2.38124999999999,2.8575,3.33375,3.80999999999999,
4.28624999999999,4.76249999999999,5.23875,5.715,6.19125,6.66749999999999,7.14374999999999,7.62,
8.09625,8.5725,9.04874999999999,9.52499999999999,10.00125,10.4775,10.95375,11.43,11.90625,
12.3825,12.85875,13.335,13.81125,14.2875,14.76375,15.24),.UNSPECIFIED.);
#1296=EDGE_CURVE('BSEAM244',#1227,#286,#1295,.T.);
#1297=ORIENTED_EDGE('',*,*,#1228,.F.);
#1298=ORIENTED_EDGE('',*,*,#287,.T.);
#1299=ORIENTED_EDGE('',*,*,#1296,.T.);
#1300=ORIENTED_EDGE('',*,*,#1296,.F.);
#1301=EDGE_LOOP('',(#1297,#1299,#1298,#1300));
#1302=FACE_BOUND('',#1301,.T.);
#1303=ADVANCED_FACE('F244',(#1302),#1220,.F.);
#1304=CARTESIAN_POINT('',(4.76249999999974,-83.185,76.2));
#1305=DIRECTION('',(0.,-1.,0.));
#1306=DIRECTION('',(0.,0.,-1.));
#1307=AXIS2_PLACEMENT_3D('',#1304,#1305,#1306);
#1308=PLANE('',#1307);
#1309=ORIENTED_EDGE('',*,*,#1228,.T.);
#1310=EDGE_LOOP('',(#1309));
#1311=FACE_BOUND('',#1310,.T.);
#1312=ADVANCED_FACE('F240',(#1311),#1308,.T.);
#1313=CARTESIAN_POINT('',(4.76249999999947,-83.185,152.4));
#1314=DIRECTION('',(0.,-1.,0.));
#1315=DIRECTION('',(0.,0.,-1.));
#1316=AXIS2_PLACEMENT_3D('',#1313,#1314,#1315);
#1317=CYLINDRICAL_SURFACE('',#1316,2.1971);
#1318=CARTESIAN_POINT('',(4.76249999999947,-83.185,152.4));
#1319=DIRECTION('',(0.,-1.,0.));
#1320=DIRECTION('',(0.,0.,-1.));
#1321=AXIS2_PLACEMENT_3D('',#1318,#1319,#1320);
#1322=CIRCLE('',#1321,2.1971);
#1323=CARTESIAN_POINT('',(4.76249999999947,-83.185,150.2029));
#1324=VERTEX_POINT('',#1323);
#1325=EDGE_CURVE('E183',#1324,#1324,#1322,.T.);
#1326=CARTESIAN_POINT('',(4.76249999999947,-83.185,150.2029));
#1327=CARTESIAN_POINT('',(4.76249999999947,-83.34375,150.2029));
#1328=CARTESIAN_POINT('',(4.76249999999947,-83.5025,150.2029));
#1329=CARTESIAN_POINT('',(4.76249999999947,-83.82,150.2029));
#1330=CARTESIAN_POINT('',(4.76249999999947,-83.97875,150.2029));
#1331=CARTESIAN_POINT('',(4.76249999999947,-84.29625,150.2029));
#1332=CARTESIAN_POINT('',(4.76249999999947,-84.455,150.2029));
#1333=CARTESIAN_POINT('',(4.76249999999947,-84.7725,150.2029));
#1334=CARTESIAN_POINT('',(4.76249999999947,-84.93125,150.2029));
#1335=CARTESIAN_POINT('',(4.76249999999947,-85.24875,150.2029));
#1336=CARTESIAN_POINT('',(4.76249999999947,-85.4075,150.2029));
#1337=CARTESIAN_POINT('',(4.76249999999947,-85.725,150.2029));
#1338=CARTESIAN_POINT('',(4.76249999999947,-85.88375,150.2029));
#1339=CARTESIAN_POINT('',(4.76249999999947,-86.20125,150.2029));
#1340=CARTESIAN_POINT('',(4.76249999999947,-86.36,150.2029));
#1341=CARTESIAN_POINT('',(4.76249999999947,-86.6775,150.2029));
#1342=CARTESIAN_POINT('',(4.76249999999947,-86.83625,150.2029));
#1343=CARTESIAN_POINT('',(4.76249999999947,-87.15375,150.2029));
#1344=CARTESIAN_POINT('',(4.76249999999947,-87.3125,150.2029));
#1345=CARTESIAN_POINT('',(4.76249999999947,-87.63,150.2029));
#1346=CARTESIAN_POINT('',(4.76249999999947,-87.78875,150.2029));
#1347=CARTESIAN_POINT('',(4.76249999999947,-88.10625,150.2029));
#1348=CARTESIAN_POINT('',(4.76249999999947,-88.265,150.2029));
#1349=CARTESIAN_POINT('',(4.76249999999947,-88.5825,150.2029));
#1350=CARTESIAN_POINT('',(4.76249999999947,-88.74125,150.2029));
#1351=CARTESIAN_POINT('',(4.76249999999947,-89.05875,150.2029));
#1352=CARTESIAN_POINT('',(4.76249999999947,-89.2175,150.2029));
#1353=CARTESIAN_POINT('',(4.76249999999947,-89.535,150.2029));
#1354=CARTESIAN_POINT('',(4.76249999999947,-89.69375,150.2029));
#1355=CARTESIAN_POINT('',(4.76249999999947,-90.01125,150.2029));
#1356=CARTESIAN_POINT('',(4.76249999999947,-90.17,150.2029));
#1357=CARTESIAN_POINT('',(4.76249999999947,-90.4875,150.2029));
#1358=CARTESIAN_POINT('',(4.76249999999947,-90.64625,150.2029));
#1359=CARTESIAN_POINT('',(4.76249999999947,-90.96375,150.2029));
#1360=CARTESIAN_POINT('',(4.76249999999947,-91.1225,150.2029));
#1361=CARTESIAN_POINT('',(4.76249999999947,-91.44,150.2029));
#1362=CARTESIAN_POINT('',(4.76249999999947,-91.59875,150.2029));
#1363=CARTESIAN_POINT('',(4.76249999999947,-91.91625,150.2029));
#1364=CARTESIAN_POINT('',(4.76249999999947,-92.075,150.2029));
#1365=CARTESIAN_POINT('',(4.76249999999947,-92.3925,150.2029));
#1366=CARTESIAN_POINT('',(4.76249999999947,-92.55125,150.2029));
#1367=CARTESIAN_POINT('',(4.76249999999947,-92.86875,150.2029));
#1368=CARTESIAN_POINT('',(4.76249999999947,-93.0275,150.2029));
#1369=CARTESIAN_POINT('',(4.76249999999947,-93.345,150.2029));
#1370=CARTESIAN_POINT('',(4.76249999999947,-93.50375,150.2029));
#1371=CARTESIAN_POINT('',(4.76249999999947,-93.82125,150.2029));
#1372=CARTESIAN_POINT('',(4.76249999999947,-93.98,150.2029));
#1373=CARTESIAN_POINT('',(4.76249999999947,-94.2975,150.2029));
#1374=CARTESIAN_POINT('',(4.76249999999947,-94.45625,150.2029));
#1375=CARTESIAN_POINT('',(4.76249999999947,-94.77375,150.2029));
#1376=CARTESIAN_POINT('',(4.76249999999947,-94.9325,150.2029));
#1377=CARTESIAN_POINT('',(4.76249999999947,-95.25,150.2029));
#1378=CARTESIAN_POINT('',(4.76249999999947,-95.40875,150.2029));
#1379=CARTESIAN_POINT('',(4.76249999999947,-95.72625,150.2029));
#1380=CARTESIAN_POINT('',(4.76249999999947,-95.885,150.2029));
#1381=CARTESIAN_POINT('',(4.76249999999947,-96.2025,150.2029));
#1382=CARTESIAN_POINT('',(4.76249999999947,-96.36125,150.2029));
#1383=CARTESIAN_POINT('',(4.76249999999947,-96.67875,150.2029));
#1384=CARTESIAN_POINT('',(4.76249999999947,-96.8375,150.2029));
#1385=CARTESIAN_POINT('',(4.76249999999947,-97.155,150.2029));
#1386=CARTESIAN_POINT('',(4.76249999999947,-97.31375,150.2029));
#1387=CARTESIAN_POINT('',(4.76249999999947,-97.63125,150.2029));
#1388=CARTESIAN_POINT('',(4.76249999999947,-97.79,150.2029));
#1389=CARTESIAN_POINT('',(4.76249999999947,-98.1075,150.2029));
#1390=CARTESIAN_POINT('',(4.76249999999947,-98.26625,150.2029));
#1391=CARTESIAN_POINT('',(4.76249999999947,-98.425,150.2029));
#1392=B_SPLINE_CURVE_WITH_KNOTS('',3,(#1326,#1327,#1328,#1329,#1330,#1331,#1332,#1333,#1334,
#1335,#1336,#1337,#1338,#1339,#1340,#1341,#1342,#1343,#1344,#1345,#1346,#1347,#1348,#1349,#1350,
#1351,#1352,#1353,#1354,#1355,#1356,#1357,#1358,#1359,#1360,#1361,#1362,#1363,#1364,#1365,#1366,
#1367,#1368,#1369,#1370,#1371,#1372,#1373,#1374,#1375,#1376,#1377,#1378,#1379,#1380,#1381,#1382,
#1383,#1384,#1385,#1386,#1387,#1388,#1389,#1390,#1391),.UNSPECIFIED.,.F.,.F.,(4,2,2,2,2,2,2,2,2,
2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,4),(0.,0.476249999999998,0.952499999999995,
1.42874999999999,1.90499999999999,2.38124999999999,2.8575,3.33375,3.80999999999999,
4.28624999999999,4.76249999999999,5.23875,5.715,6.19125,6.66749999999999,7.14374999999999,7.62,
8.09625,8.5725,9.04874999999999,9.52499999999999,10.00125,10.4775,10.95375,11.43,11.90625,
12.3825,12.85875,13.335,13.81125,14.2875,14.76375,15.24),.UNSPECIFIED.);
#1393=EDGE_CURVE('BSEAM243',#1324,#275,#1392,.T.);
#1394=ORIENTED_EDGE('',*,*,#1325,.F.);
#1395=ORIENTED_EDGE('',*,*,#276,.T.);
#1396=ORIENTED_EDGE('',*,*,#1393,.T.);
#1397=ORIENTED_EDGE('',*,*,#1393,.F.);
#1398=EDGE_LOOP('',(#1394,#1396,#1395,#1397));
#1399=FACE_BOUND('',#1398,.T.);
#1400=ADVANCED_FACE('F243',(#1399),#1317,.F.);
#1401=CARTESIAN_POINT('',(4.76249999999947,-83.185,152.4));
#1402=DIRECTION('',(0.,-1.,0.));
#1403=DIRECTION('',(0.,0.,-1.));
#1404=AXIS2_PLACEMENT_3D('',#1401,#1402,#1403);
#1405=PLANE('',#1404);
#1406=ORIENTED_EDGE('',*,*,#1325,.T.);
#1407=EDGE_LOOP('',(#1406));
#1408=FACE_BOUND('',#1407,.T.);
#1409=ADVANCED_FACE('F250',(#1408),#1405,.T.);
#1410=CARTESIAN_POINT('',(4.76250000000188,-83.185,-76.2));
#1411=DIRECTION('',(0.,-1.,0.));
#1412=DIRECTION('',(0.,0.,-1.));
#1413=AXIS2_PLACEMENT_3D('',#1410,#1411,#1412);
#1414=CYLINDRICAL_SURFACE('',#1413,2.1971);
#1415=CARTESIAN_POINT('',(4.76250000000188,-83.185,-76.2));
#1416=DIRECTION('',(0.,-1.,0.));
#1417=DIRECTION('',(0.,0.,-1.));
#1418=AXIS2_PLACEMENT_3D('',#1415,#1416,#1417);
#1419=CIRCLE('',#1418,2.1971);
#1420=CARTESIAN_POINT('',(4.76250000000188,-83.185,-78.3971));
#1421=VERTEX_POINT('',#1420);
#1422=EDGE_CURVE('E177',#1421,#1421,#1419,.T.);
#1423=CARTESIAN_POINT('',(4.76250000000188,-83.185,-78.3971));
#1424=CARTESIAN_POINT('',(4.76250000000188,-83.34375,-78.3971));
#1425=CARTESIAN_POINT('',(4.76250000000188,-83.5025,-78.3971));
#1426=CARTESIAN_POINT('',(4.76250000000188,-83.82,-78.3971));
#1427=CARTESIAN_POINT('',(4.76250000000188,-83.97875,-78.3971));
#1428=CARTESIAN_POINT('',(4.76250000000188,-84.29625,-78.3971));
#1429=CARTESIAN_POINT('',(4.76250000000188,-84.455,-78.3971));
#1430=CARTESIAN_POINT('',(4.76250000000188,-84.7725,-78.3971));
#1431=CARTESIAN_POINT('',(4.76250000000188,-84.93125,-78.3971));
#1432=CARTESIAN_POINT('',(4.76250000000188,-85.24875,-78.3971));
#1433=CARTESIAN_POINT('',(4.76250000000188,-85.4075,-78.3971));
#1434=CARTESIAN_POINT('',(4.76250000000188,-85.725,-78.3971));
#1435=CARTESIAN_POINT('',(4.76250000000188,-85.88375,-78.3971));
#1436=CARTESIAN_POINT('',(4.76250000000188,-86.20125,-78.3971));
#1437=CARTESIAN_POINT('',(4.76250000000188,-86.36,-78.3971));
#1438=CARTESIAN_POINT('',(4.76250000000188,-86.6775,-78.3971));
#1439=CARTESIAN_POINT('',(4.76250000000188,-86.83625,-78.3971));
#1440=CARTESIAN_POINT('',(4.76250000000188,-87.15375,-78.3971));
#1441=CARTESIAN_POINT('',(4.76250000000188,-87.3125,-78.3971));
#1442=CARTESIAN_POINT('',(4.76250000000188,-87.63,-78.3971));
#1443=CARTESIAN_POINT('',(4.76250000000188,-87.78875,-78.3971));
#1444=CARTESIAN_POINT('',(4.76250000000188,-88.10625,-78.3971));
#1445=CARTESIAN_POINT('',(4.76250000000188,-88.265,-78.3971));
#1446=CARTESIAN_POINT('',(4.76250000000188,-88.5825,-78.3971));
#1447=CARTESIAN_POINT('',(4.76250000000188,-88.74125,-78.3971));
#1448=CARTESIAN_POINT('',(4.76250000000188,-89.05875,-78.3971));
#1449=CARTESIAN_POINT('',(4.76250000000188,-89.2175,-78.3971));
#1450=CARTESIAN_POINT('',(4.76250000000188,-89.535,-78.3971));
#1451=CARTESIAN_POINT('',(4.76250000000188,-89.69375,-78.3971));
#1452=CARTESIAN_POINT('',(4.76250000000188,-90.01125,-78.3971));
#1453=CARTESIAN_POINT('',(4.76250000000188,-90.17,-78.3971));
#1454=CARTESIAN_POINT('',(4.76250000000188,-90.4875,-78.3971));
#1455=CARTESIAN_POINT('',(4.76250000000188,-90.64625,-78.3971));
#1456=CARTESIAN_POINT('',(4.76250000000188,-90.96375,-78.3971));
#1457=CARTESIAN_POINT('',(4.76250000000188,-91.1225,-78.3971));
#1458=CARTESIAN_POINT('',(4.76250000000188,-91.44,-78.3971));
#1459=CARTESIAN_POINT('',(4.76250000000188,-91.59875,-78.3971));
#1460=CARTESIAN_POINT('',(4.76250000000188,-91.91625,-78.3971));
#1461=CARTESIAN_POINT('',(4.76250000000188,-92.075,-78.3971));
#1462=CARTESIAN_POINT('',(4.76250000000188,-92.3925,-78.3971));
#1463=CARTESIAN_POINT('',(4.76250000000188,-92.55125,-78.3971));
#1464=CARTESIAN_POINT('',(4.76250000000188,-92.86875,-78.3971));
#1465=CARTESIAN_POINT('',(4.76250000000188,-93.0275,-78.3971));
#1466=CARTESIAN_POINT('',(4.76250000000188,-93.345,-78.3971));
#1467=CARTESIAN_POINT('',(4.76250000000188,-93.50375,-78.3971));
#1468=CARTESIAN_POINT('',(4.76250000000188,-93.82125,-78.3971));
#1469=CARTESIAN_POINT('',(4.76250000000188,-93.98,-78.3971));
#1470=CARTESIAN_POINT('',(4.76250000000188,-94.2975,-78.3971));
#1471=CARTESIAN_POINT('',(4.76250000000188,-94.45625,-78.3971));
#1472=CARTESIAN_POINT('',(4.76250000000188,-94.77375,-78.3971));
#1473=CARTESIAN_POINT('',(4.76250000000188,-94.9325,-78.3971));
#1474=CARTESIAN_POINT('',(4.76250000000188,-95.25,-78.3971));
#1475=CARTESIAN_POINT('',(4.76250000000188,-95.40875,-78.3971));
#1476=CARTESIAN_POINT('',(4.76250000000188,-95.72625,-78.3971));
#1477=CARTESIAN_POINT('',(4.76250000000188,-95.885,-78.3971));
#1478=CARTESIAN_POINT('',(4.76250000000188,-96.2025,-78.3971));
#1479=CARTESIAN_POINT('',(4.76250000000188,-96.36125,-78.3971));
#1480=CARTESIAN_POINT('',(4.76250000000188,-96.67875,-78.3971));
#1481=CARTESIAN_POINT('',(4.76250000000188,-96.8375,-78.3971));
#1482=CARTESIAN_POINT('',(4.76250000000188,-97.155,-78.3971));
#1483=CARTESIAN_POINT('',(4.76250000000188,-97.31375,-78.3971));
#1484=CARTESIAN_POINT('',(4.76250000000188,-97.63125,-78.3971));
#1485=CARTESIAN_POINT('',(4.76250000000188,-97.79,-78.3971));
#1486=CARTESIAN_POINT('',(4.76250000000188,-98.1075,-78.3971));
#1487=CARTESIAN_POINT('',(4.76250000000188,-98.26625,-78.3971));
#1488=CARTESIAN_POINT('',(4.76250000000188,-98.425,-78.3971));
#1489=B_SPLINE_CURVE_WITH_KNOTS('',3,(#1423,#1424,#1425,#1426,#1427,#1428,#1429,#1430,#1431,
#1432,#1433,#1434,#1435,#1436,#1437,#1438,#1439,#1440,#1441,#1442,#1443,#1444,#1445,#1446,#1447,
#1448,#1449,#1450,#1451,#1452,#1453,#1454,#1455,#1456,#1457,#1458,#1459,#1460,#1461,#1462,#1463,
#1464,#1465,#1466,#1467,#1468,#1469,#1470,#1471,#1472,#1473,#1474,#1475,#1476,#1477,#1478,#1479,
#1480,#1481,#1482,#1483,#1484,#1485,#1486,#1487,#1488),.UNSPECIFIED.,.F.,.F.,(4,2,2,2,2,2,2,2,2,
2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,4),(0.,0.476249999999998,0.952499999999995,
1.42874999999999,1.90499999999999,2.38124999999999,2.8575,3.33375,3.80999999999999,
4.28624999999999,4.76249999999999,5.23875,5.715,6.19125,6.66749999999999,7.14374999999999,7.62,
8.09625,8.5725,9.04874999999999,9.52499999999999,10.00125,10.4775,10.95375,11.43,11.90625,
12.3825,12.85875,13.335,13.81125,14.2875,14.76375,15.24),.UNSPECIFIED.);
#1490=EDGE_CURVE('BSEAM253',#1421,#264,#1489,.T.);
#1491=ORIENTED_EDGE('',*,*,#1422,.F.);
#1492=ORIENTED_EDGE('',*,*,#265,.T.);
#1493=ORIENTED_EDGE('',*,*,#1490,.T.);
#1494=ORIENTED_EDGE('',*,*,#1490,.F.);
#1495=EDGE_LOOP('',(#1491,#1493,#1492,#1494));
#1496=FACE_BOUND('',#1495,.T.);
#1497=ADVANCED_FACE('F253',(#1496),#1414,.F.);
#1498=CARTESIAN_POINT('',(4.76250000000188,-83.185,-76.2));
#1499=DIRECTION('',(0.,-1.,0.));
#1500=DIRECTION('',(0.,0.,-1.));
#1501=AXIS2_PLACEMENT_3D('',#1498,#1499,#1500);
#1502=PLANE('',#1501);
#1503=ORIENTED_EDGE('',*,*,#1422,.T.);
#1504=EDGE_LOOP('',(#1503));
#1505=FACE_BOUND('',#1504,.T.);
#1506=ADVANCED_FACE('F258',(#1505),#1502,.T.);
#1507=CARTESIAN_POINT('',(4.76250000000376,-83.185,-152.4));
#1508=DIRECTION('',(0.,-1.,0.));
#1509=DIRECTION('',(0.,0.,-1.));
#1510=AXIS2_PLACEMENT_3D('',#1507,#1508,#1509);
#1511=CYLINDRICAL_SURFACE('',#1510,2.1971);
#1512=CARTESIAN_POINT('',(4.76250000000376,-83.185,-152.4));
#1513=DIRECTION('',(0.,-1.,0.));
#1514=DIRECTION('',(0.,0.,-1.));
#1515=AXIS2_PLACEMENT_3D('',#1512,#1513,#1514);
#1516=CIRCLE('',#1515,2.1971);
#1517=CARTESIAN_POINT('',(4.76250000000376,-83.185,-154.5971));
#1518=VERTEX_POINT('',#1517);
#1519=EDGE_CURVE('E170',#1518,#1518,#1516,.T.);
#1520=CARTESIAN_POINT('',(4.76250000000376,-83.185,-154.5971));
#1521=CARTESIAN_POINT('',(4.76250000000376,-83.34375,-154.5971));
#1522=CARTESIAN_POINT('',(4.76250000000376,-83.5025,-154.5971));
#1523=CARTESIAN_POINT('',(4.76250000000376,-83.82,-154.5971));
#1524=CARTESIAN_POINT('',(4.76250000000376,-83.97875,-154.5971));
#1525=CARTESIAN_POINT('',(4.76250000000376,-84.29625,-154.5971));
#1526=CARTESIAN_POINT('',(4.76250000000376,-84.455,-154.5971));
#1527=CARTESIAN_POINT('',(4.76250000000376,-84.7725,-154.5971));
#1528=CARTESIAN_POINT('',(4.76250000000376,-84.93125,-154.5971));
#1529=CARTESIAN_POINT('',(4.76250000000376,-85.24875,-154.5971));
#1530=CARTESIAN_POINT('',(4.76250000000376,-85.4075,-154.5971));
#1531=CARTESIAN_POINT('',(4.76250000000376,-85.725,-154.5971));
#1532=CARTESIAN_POINT('',(4.76250000000376,-85.88375,-154.5971));
#1533=CARTESIAN_POINT('',(4.76250000000376,-86.20125,-154.5971));
#1534=CARTESIAN_POINT('',(4.76250000000376,-86.36,-154.5971));
#1535=CARTESIAN_POINT('',(4.76250000000376,-86.6775,-154.5971));
#1536=CARTESIAN_POINT('',(4.76250000000376,-86.83625,-154.5971));
#1537=CARTESIAN_POINT('',(4.76250000000376,-87.15375,-154.5971));
#1538=CARTESIAN_POINT('',(4.76250000000376,-87.3125,-154.5971));
#1539=CARTESIAN_POINT('',(4.76250000000376,-87.63,-154.5971));
#1540=CARTESIAN_POINT('',(4.76250000000376,-87.78875,-154.5971));
#1541=CARTESIAN_POINT('',(4.76250000000376,-88.10625,-154.5971));
#1542=CARTESIAN_POINT('',(4.76250000000376,-88.265,-154.5971));
#1543=CARTESIAN_POINT('',(4.76250000000376,-88.5825,-154.5971));
#1544=CARTESIAN_POINT('',(4.76250000000376,-88.74125,-154.5971));
#1545=CARTESIAN_POINT('',(4.76250000000376,-89.05875,-154.5971));
#1546=CARTESIAN_POINT('',(4.76250000000376,-89.2175,-154.5971));
#1547=CARTESIAN_POINT('',(4.76250000000376,-89.535,-154.5971));
#1548=CARTESIAN_POINT('',(4.76250000000376,-89.69375,-154.5971));
#1549=CARTESIAN_POINT('',(4.76250000000376,-90.01125,-154.5971));
#1550=CARTESIAN_POINT('',(4.76250000000376,-90.17,-154.5971));
#1551=CARTESIAN_POINT('',(4.76250000000376,-90.4875,-154.5971));
#1552=CARTESIAN_POINT('',(4.76250000000376,-90.64625,-154.5971));
#1553=CARTESIAN_POINT('',(4.76250000000376,-90.96375,-154.5971));
#1554=CARTESIAN_POINT('',(4.76250000000376,-91.1225,-154.5971));
#1555=CARTESIAN_POINT('',(4.76250000000376,-91.44,-154.5971));
#1556=CARTESIAN_POINT('',(4.76250000000376,-91.59875,-154.5971));
#1557=CARTESIAN_POINT('',(4.76250000000376,-91.91625,-154.5971));
#1558=CARTESIAN_POINT('',(4.76250000000376,-92.075,-154.5971));
#1559=CARTESIAN_POINT('',(4.76250000000376,-92.3925,-154.5971));
#1560=CARTESIAN_POINT('',(4.76250000000376,-92.55125,-154.5971));
#1561=CARTESIAN_POINT('',(4.76250000000376,-92.86875,-154.5971));
#1562=CARTESIAN_POINT('',(4.76250000000376,-93.0275,-154.5971));
#1563=CARTESIAN_POINT('',(4.76250000000376,-93.345,-154.5971));
#1564=CARTESIAN_POINT('',(4.76250000000376,-93.50375,-154.5971));
#1565=CARTESIAN_POINT('',(4.76250000000376,-93.82125,-154.5971));
#1566=CARTESIAN_POINT('',(4.76250000000376,-93.98,-154.5971));
#1567=CARTESIAN_POINT('',(4.76250000000376,-94.2975,-154.5971));
#1568=CARTESIAN_POINT('',(4.76250000000376,-94.45625,-154.5971));
#1569=CARTESIAN_POINT('',(4.76250000000376,-94.77375,-154.5971));
#1570=CARTESIAN_POINT('',(4.76250000000376,-94.9325,-154.5971));
#1571=CARTESIAN_POINT('',(4.76250000000376,-95.25,-154.5971));
#1572=CARTESIAN_POINT('',(4.76250000000376,-95.40875,-154.5971));
#1573=CARTESIAN_POINT('',(4.76250000000376,-95.72625,-154.5971));
#1574=CARTESIAN_POINT('',(4.76250000000376,-95.885,-154.5971));
#1575=CARTESIAN_POINT('',(4.76250000000376,-96.2025,-154.5971));
#1576=CARTESIAN_POINT('',(4.76250000000376,-96.36125,-154.5971));
#1577=CARTESIAN_POINT('',(4.76250000000376,-96.67875,-154.5971));
#1578=CARTESIAN_POINT('',(4.76250000000376,-96.8375,-154.5971));
#1579=CARTESIAN_POINT('',(4.76250000000376,-97.155,-154.5971));
#1580=CARTESIAN_POINT('',(4.76250000000376,-97.31375,-154.5971));
#1581=CARTESIAN_POINT('',(4.76250000000376,-97.63125,-154.5971));
#1582=CARTESIAN_POINT('',(4.76250000000376,-97.79,-154.5971));
#1583=CARTESIAN_POINT('',(4.76250000000376,-98.1075,-154.5971));
#1584=CARTESIAN_POINT('',(4.76250000000376,-98.26625,-154.5971));
#1585=CARTESIAN_POINT('',(4.76250000000376,-98.425,-154.5971));
#1586=B_SPLINE_CURVE_WITH_KNOTS('',3,(#1520,#1521,#1522,#1523,#1524,#1525,#1526,#1527,#1528,
#1529,#1530,#1531,#1532,#1533,#1534,#1535,#1536,#1537,#1538,#1539,#1540,#1541,#1542,#1543,#1544,
#1545,#1546,#1547,#1548,#1549,#1550,#1551,#1552,#1553,#1554,#1555,#1556,#1557,#1558,#1559,#1560,
#1561,#1562,#1563,#1564,#1565,#1566,#1567,#1568,#1569,#1570,#1571,#1572,#1573,#1574,#1575,#1576,
#1577,#1578,#1579,#1580,#1581,#1582,#1583,#1584,#1585),.UNSPECIFIED.,.F.,.F.,(4,2,2,2,2,2,2,2,2,
2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,4),(0.,0.476249999999998,0.952499999999995,
1.42874999999999,1.90499999999999,2.38124999999999,2.8575,3.33375,3.80999999999999,
4.28624999999999,4.76249999999999,5.23875,5.715,6.19125,6.66749999999999,7.14374999999999,7.62,
8.09625,8.5725,9.04874999999999,9.52499999999999,10.00125,10.4775,10.95375,11.43,11.90625,
12.3825,12.85875,13.335,13.81125,14.2875,14.76375,15.24),.UNSPECIFIED.);
#1587=EDGE_CURVE('BSEAM234',#1518,#253,#1586,.T.);
#1588=ORIENTED_EDGE('',*,*,#1519,.F.);
#1589=ORIENTED_EDGE('',*,*,#254,.T.);
#1590=ORIENTED_EDGE('',*,*,#1587,.T.);
#1591=ORIENTED_EDGE('',*,*,#1587,.F.);
#1592=EDGE_LOOP('',(#1588,#1590,#1589,#1591));
#1593=FACE_BOUND('',#1592,.T.);
#1594=ADVANCED_FACE('F234',(#1593),#1511,.F.);
#1595=CARTESIAN_POINT('',(4.76250000000376,-83.185,-152.4));
#1596=DIRECTION('',(0.,-1.,0.));
#1597=DIRECTION('',(0.,0.,-1.));
#1598=AXIS2_PLACEMENT_3D('',#1595,#1596,#1597);
#1599=PLANE('',#1598);
#1600=ORIENTED_EDGE('',*,*,#1519,.T.);
#1601=EDGE_LOOP('',(#1600));
#1602=FACE_BOUND('',#1601,.T.);
#1603=ADVANCED_FACE('F225',(#1602),#1599,.T.);
#1604=CARTESIAN_POINT('',(4.7625,0.,-149.86));
#1605=DIRECTION('',(0.,0.,-1.));
#1606=DIRECTION('',(-1.,0.,0.));
#1607=AXIS2_PLACEMENT_3D('',#1604,#1605,#1606);
#1608=CYLINDRICAL_SURFACE('',#1607,2.1971);
#1609=CARTESIAN_POINT('',(4.7625,0.,-149.86));
#1610=DIRECTION('',(0.,0.,-1.));
#1611=DIRECTION('',(-1.,0.,0.));
#1612=AXIS2_PLACEMENT_3D('',#1609,#1610,#1611);
#1613=CIRCLE('',#1612,2.1971);
#1614=CARTESIAN_POINT('',(2.5654,0.,-149.86));
#1615=VERTEX_POINT('',#1614);
#1616=EDGE_CURVE('E171',#1615,#1615,#1613,.T.);
#1617=CARTESIAN_POINT('',(2.5654,0.,-149.86));
#1618=CARTESIAN_POINT('',(2.5654,0.,-150.01875));
#1619=CARTESIAN_POINT('',(2.5654,0.,-150.1775));
#1620=CARTESIAN_POINT('',(2.5654,0.,-150.495));
#1621=CARTESIAN_POINT('',(2.5654,0.,-150.65375));
#1622=CARTESIAN_POINT('',(2.5654,0.,-150.97125));
#1623=CARTESIAN_POINT('',(2.5654,0.,-151.13));
#1624=CARTESIAN_POINT('',(2.5654,0.,-151.4475));
#1625=CARTESIAN_POINT('',(2.5654,0.,-151.60625));
#1626=CARTESIAN_POINT('',(2.5654,0.,-151.92375));
#1627=CARTESIAN_POINT('',(2.5654,0.,-152.0825));
#1628=CARTESIAN_POINT('',(2.5654,0.,-152.4));
#1629=CARTESIAN_POINT('',(2.5654,0.,-152.55875));
#1630=CARTESIAN_POINT('',(2.5654,0.,-152.87625));
#1631=CARTESIAN_POINT('',(2.5654,0.,-153.035));
#1632=CARTESIAN_POINT('',(2.5654,0.,-153.3525));
#1633=CARTESIAN_POINT('',(2.5654,0.,-153.51125));
#1634=CARTESIAN_POINT('',(2.5654,0.,-153.82875));
#1635=CARTESIAN_POINT('',(2.5654,0.,-153.9875));
#1636=CARTESIAN_POINT('',(2.5654,0.,-154.305));
#1637=CARTESIAN_POINT('',(2.5654,0.,-154.46375));
#1638=CARTESIAN_POINT('',(2.5654,0.,-154.78125));
#1639=CARTESIAN_POINT('',(2.5654,0.,-154.94));
#1640=CARTESIAN_POINT('',(2.5654,0.,-155.2575));
#1641=CARTESIAN_POINT('',(2.5654,0.,-155.41625));
#1642=CARTESIAN_POINT('',(2.5654,0.,-155.73375));
#1643=CARTESIAN_POINT('',(2.5654,0.,-155.8925));
#1644=CARTESIAN_POINT('',(2.5654,0.,-156.21));
#1645=CARTESIAN_POINT('',(2.5654,0.,-156.36875));
#1646=CARTESIAN_POINT('',(2.5654,0.,-156.68625));
#1647=CARTESIAN_POINT('',(2.5654,0.,-156.845));
#1648=CARTESIAN_POINT('',(2.5654,0.,-157.1625));
#1649=CARTESIAN_POINT('',(2.5654,0.,-157.32125));
#1650=CARTESIAN_POINT('',(2.5654,0.,-157.63875));
#1651=CARTESIAN_POINT('',(2.5654,0.,-157.7975));
#1652=CARTESIAN_POINT('',(2.5654,0.,-158.115));
#1653=CARTESIAN_POINT('',(2.5654,0.,-158.27375));
#1654=CARTESIAN_POINT('',(2.5654,0.,-158.59125));
#1655=CARTESIAN_POINT('',(2.5654,0.,-158.75));
#1656=CARTESIAN_POINT('',(2.5654,0.,-159.0675));
#1657=CARTESIAN_POINT('',(2.5654,0.,-159.22625));
#1658=CARTESIAN_POINT('',(2.5654,0.,-159.54375));
#1659=CARTESIAN_POINT('',(2.5654,0.,-159.7025));
#1660=CARTESIAN_POINT('',(2.5654,0.,-160.02));
#1661=CARTESIAN_POINT('',(2.5654,0.,-160.17875));
#1662=CARTESIAN_POINT('',(2.5654,0.,-160.49625));
#1663=CARTESIAN_POINT('',(2.5654,0.,-160.655));
#1664=CARTESIAN_POINT('',(2.5654,0.,-160.9725));
#1665=CARTESIAN_POINT('',(2.5654,0.,-161.13125));
#1666=CARTESIAN_POINT('',(2.5654,0.,-161.44875));
#1667=CARTESIAN_POINT('',(2.5654,0.,-161.6075));
#1668=CARTESIAN_POINT('',(2.5654,0.,-161.925));
#1669=CARTESIAN_POINT('',(2.5654,0.,-162.08375));
#1670=CARTESIAN_POINT('',(2.5654,0.,-162.40125));
#1671=CARTESIAN_POINT('',(2.5654,0.,-162.56));
#1672=CARTESIAN_POINT('',(2.5654,0.,-162.8775));
#1673=CARTESIAN_POINT('',(2.5654,0.,-163.03625));
#1674=CARTESIAN_POINT('',(2.5654,0.,-163.35375));
#1675=CARTESIAN_POINT('',(2.5654,0.,-163.5125));
#1676=CARTESIAN_POINT('',(2.5654,0.,-163.83));
#1677=CARTESIAN_POINT('',(2.5654,0.,-163.98875));
#1678=CARTESIAN_POINT('',(2.5654,0.,-164.30625));
#1679=CARTESIAN_POINT('',(2.5654,0.,-164.465));
#1680=CARTESIAN_POINT('',(2.5654,0.,-164.7825));
#1681=CARTESIAN_POINT('',(2.5654,0.,-164.94125));
#1682=CARTESIAN_POINT('',(2.5654,0.,-165.1));
#1683=B_SPLINE_CURVE_WITH_KNOTS('',3,(#1617,#1618,#1619,#1620,#1621,#1622,#1623,#1624,#1625,
#1626,#1627,#1628,#1629,#1630,#1631,#1632,#1633,#1634,#1635,#1636,#1637,#1638,#1639,#1640,#1641,
#1642,#1643,#1644,#1645,#1646,#1647,#1648,#1649,#1650,#1651,#1652,#1653,#1654,#1655,#1656,#1657,
#1658,#1659,#1660,#1661,#1662,#1663,#1664,#1665,#1666,#1667,#1668,#1669,#1670,#1671,#1672,#1673,
#1674,#1675,#1676,#1677,#1678,#1679,#1680,#1681,#1682),.UNSPECIFIED.,.F.,.F.,(4,2,2,2,2,2,2,2,2,
2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,4),(0.,0.476249999999984,0.952499999999995,
1.42874999999998,1.90499999999999,2.38124999999997,2.85749999999998,3.33375,3.80999999999998,
4.28624999999999,4.76249999999998,5.23874999999999,5.715,6.19124999999998,6.66749999999999,
7.14374999999998,7.61999999999999,8.09625,8.57249999999998,9.04874999999999,9.52499999999998,
10.00125,10.4775,10.95375,11.43,11.90625,12.3825,12.85875,13.335,13.81125,14.2875,14.76375,
15.24),.UNSPECIFIED.);
#1684=EDGE_CURVE('BSEAM223',#1615,#52,#1683,.T.);
#1685=ORIENTED_EDGE('',*,*,#1616,.F.);
#1686=ORIENTED_EDGE('',*,*,#53,.T.);
#1687=ORIENTED_EDGE('',*,*,#1684,.T.);
#1688=ORIENTED_EDGE('',*,*,#1684,.F.);
#1689=EDGE_LOOP('',(#1685,#1687,#1686,#1688));
#1690=FACE_BOUND('',#1689,.T.);
#1691=ADVANCED_FACE('F223',(#1690),#1608,.F.);
#1692=CARTESIAN_POINT('',(4.7625,0.,-149.86));
#1693=DIRECTION('',(0.,0.,-1.));
#1694=DIRECTION('',(-1.,0.,0.));
#1695=AXIS2_PLACEMENT_3D('',#1692,#1693,#1694);
#1696=PLANE('',#1695);
#1697=ORIENTED_EDGE('',*,*,#1616,.T.);
#1698=EDGE_LOOP('',(#1697));
#1699=FACE_BOUND('',#1698,.T.);
#1700=ADVANCED_FACE('F214',(#1699),#1696,.T.);
#1701=CARTESIAN_POINT('',(4.76250000000027,76.2,-149.86));
#1702=DIRECTION('',(0.,0.,-1.));
#1703=DIRECTION('',(-1.,0.,0.));
#1704=AXIS2_PLACEMENT_3D('',#1701,#1702,#1703);
#1705=CYLINDRICAL_SURFACE('',#1704,2.1971);
#1706=CARTESIAN_POINT('',(4.76250000000027,76.2,-149.86));
#1707=DIRECTION('',(0.,0.,-1.));
#1708=DIRECTION('',(-1.,0.,0.));
#1709=AXIS2_PLACEMENT_3D('',#1706,#1707,#1708);
#1710=CIRCLE('',#1709,2.1971);
#1711=CARTESIAN_POINT('',(2.56540000000027,76.2,-149.86));
#1712=VERTEX_POINT('',#1711);
#1713=EDGE_CURVE('E194',#1712,#1712,#1710,.T.);
#1714=CARTESIAN_POINT('',(2.56540000000027,76.2,-149.86));
#1715=CARTESIAN_POINT('',(2.56540000000027,76.2,-150.01875));
#1716=CARTESIAN_POINT('',(2.56540000000027,76.2,-150.1775));
#1717=CARTESIAN_POINT('',(2.56540000000027,76.2,-150.495));
#1718=CARTESIAN_POINT('',(2.56540000000027,76.2,-150.65375));
#1719=CARTESIAN_POINT('',(2.56540000000027,76.2,-150.97125));
#1720=CARTESIAN_POINT('',(2.56540000000027,76.2,-151.13));
#1721=CARTESIAN_POINT('',(2.56540000000027,76.2,-151.4475));
#1722=CARTESIAN_POINT('',(2.56540000000027,76.2,-151.60625));
#1723=CARTESIAN_POINT('',(2.56540000000027,76.2,-151.92375));
#1724=CARTESIAN_POINT('',(2.56540000000027,76.2,-152.0825));
#1725=CARTESIAN_POINT('',(2.56540000000027,76.2,-152.4));
#1726=CARTESIAN_POINT('',(2.56540000000027,76.2,-152.55875));
#1727=CARTESIAN_POINT('',(2.56540000000027,76.2,-152.87625));
#1728=CARTESIAN_POINT('',(2.56540000000027,76.2,-153.035));
#1729=CARTESIAN_POINT('',(2.56540000000027,76.2,-153.3525));
#1730=CARTESIAN_POINT('',(2.56540000000027,76.2,-153.51125));
#1731=CARTESIAN_POINT('',(2.56540000000027,76.2,-153.82875));
#1732=CARTESIAN_POINT('',(2.56540000000027,76.2,-153.9875));
#1733=CARTESIAN_POINT('',(2.56540000000027,76.2,-154.305));
#1734=CARTESIAN_POINT('',(2.56540000000027,76.2,-154.46375));
#1735=CARTESIAN_POINT('',(2.56540000000027,76.2,-154.78125));
#1736=CARTESIAN_POINT('',(2.56540000000027,76.2,-154.94));
#1737=CARTESIAN_POINT('',(2.56540000000027,76.2,-155.2575));
#1738=CARTESIAN_POINT('',(2.56540000000027,76.2,-155.41625));
#1739=CARTESIAN_POINT('',(2.56540000000027,76.2,-155.73375));
#1740=CARTESIAN_POINT('',(2.56540000000027,76.2,-155.8925));
#1741=CARTESIAN_POINT('',(2.56540000000027,76.2,-156.21));
#1742=CARTESIAN_POINT('',(2.56540000000027,76.2,-156.36875));
#1743=CARTESIAN_POINT('',(2.56540000000027,76.2,-156.68625));
#1744=CARTESIAN_POINT('',(2.56540000000027,76.2,-156.845));
#1745=CARTESIAN_POINT('',(2.56540000000027,76.2,-157.1625));
#1746=CARTESIAN_POINT('',(2.56540000000027,76.2,-157.32125));
#1747=CARTESIAN_POINT('',(2.56540000000027,76.2,-157.63875));
#1748=CARTESIAN_POINT('',(2.56540000000027,76.2,-157.7975));
#1749=CARTESIAN_POINT('',(2.56540000000027,76.2,-158.115));
#1750=CARTESIAN_POINT('',(2.56540000000027,76.2,-158.27375));
#1751=CARTESIAN_POINT('',(2.56540000000027,76.2,-158.59125));
#1752=CARTESIAN_POINT('',(2.56540000000027,76.2,-158.75));
#1753=CARTESIAN_POINT('',(2.56540000000027,76.2,-159.0675));
#1754=CARTESIAN_POINT('',(2.56540000000027,76.2,-159.22625));
#1755=CARTESIAN_POINT('',(2.56540000000027,76.2,-159.54375));
#1756=CARTESIAN_POINT('',(2.56540000000027,76.2,-159.7025));
#1757=CARTESIAN_POINT('',(2.56540000000027,76.2,-160.02));
#1758=CARTESIAN_POINT('',(2.56540000000027,76.2,-160.17875));
#1759=CARTESIAN_POINT('',(2.56540000000027,76.2,-160.49625));
#1760=CARTESIAN_POINT('',(2.56540000000027,76.2,-160.655));
#1761=CARTESIAN_POINT('',(2.56540000000027,76.2,-160.9725));
#1762=CARTESIAN_POINT('',(2.56540000000027,76.2,-161.13125));
#1763=CARTESIAN_POINT('',(2.56540000000027,76.2,-161.44875));
#1764=CARTESIAN_POINT('',(2.56540000000027,76.2,-161.6075));
#1765=CARTESIAN_POINT('',(2.56540000000027,76.2,-161.925));
#1766=CARTESIAN_POINT('',(2.56540000000027,76.2,-162.08375));
#1767=CARTESIAN_POINT('',(2.56540000000027,76.2,-162.40125));
#1768=CARTESIAN_POINT('',(2.56540000000027,76.2,-162.56));
#1769=CARTESIAN_POINT('',(2.56540000000027,76.2,-162.8775));
#1770=CARTESIAN_POINT('',(2.56540000000027,76.2,-163.03625));
#1771=CARTESIAN_POINT('',(2.56540000000027,76.2,-163.35375));
#1772=CARTESIAN_POINT('',(2.56540000000027,76.2,-163.5125));
#1773=CARTESIAN_POINT('',(2.56540000000027,76.2,-163.83));
#1774=CARTESIAN_POINT('',(2.56540000000027,76.2,-163.98875));
#1775=CARTESIAN_POINT('',(2.56540000000027,76.2,-164.30625));
#1776=CARTESIAN_POINT('',(2.56540000000027,76.2,-164.465));
#1777=CARTESIAN_POINT('',(2.56540000000027,76.2,-164.7825));
#1778=CARTESIAN_POINT('',(2.56540000000027,76.2,-164.94125));
#1779=CARTESIAN_POINT('',(2.56540000000027,76.2,-165.1));
#1780=B_SPLINE_CURVE_WITH_KNOTS('',3,(#1714,#1715,#1716,#1717,#1718,#1719,#1720,#1721,#1722,
#1723,#1724,#1725,#1726,#1727,#1728,#1729,#1730,#1731,#1732,#1733,#1734,#1735,#1736,#1737,#1738,
#1739,#1740,#1741,#1742,#1743,#1744,#1745,#1746,#1747,#1748,#1749,#1750,#1751,#1752,#1753,#1754,
#1755,#1756,#1757,#1758,#1759,#1760,#1761,#1762,#1763,#1764,#1765,#1766,#1767,#1768,#1769,#1770,
#1771,#1772,#1773,#1774,#1775,#1776,#1777,#1778,#1779),.UNSPECIFIED.,.F.,.F.,(4,2,2,2,2,2,2,2,2,
2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,4),(0.,0.476249999999984,0.952499999999995,
1.42874999999998,1.90499999999999,2.38124999999997,2.85749999999998,3.33375,3.80999999999998,
4.28624999999999,4.76249999999998,5.23874999999999,5.715,6.19124999999998,6.66749999999999,
7.14374999999998,7.61999999999999,8.09625,8.57249999999998,9.04874999999999,9.52499999999998,
10.00125,10.4775,10.95375,11.43,11.90625,12.3825,12.85875,13.335,13.81125,14.2875,14.76375,
15.24),.UNSPECIFIED.);
#1781=EDGE_CURVE('BSEAM211',#1712,#41,#1780,.T.);
#1782=ORIENTED_EDGE('',*,*,#1713,.F.);
#1783=ORIENTED_EDGE('',*,*,#42,.T.);
#1784=ORIENTED_EDGE('',*,*,#1781,.T.);
#1785=ORIENTED_EDGE('',*,*,#1781,.F.);
#1786=EDGE_LOOP('',(#1782,#1784,#1783,#1785));
#1787=FACE_BOUND('',#1786,.T.);
#1788=ADVANCED_FACE('F211',(#1787),#1705,.F.);
#1789=CARTESIAN_POINT('',(4.76250000000027,76.2,-149.86));
#1790=DIRECTION('',(0.,0.,-1.));
#1791=DIRECTION('',(-1.,0.,0.));
#1792=AXIS2_PLACEMENT_3D('',#1789,#1790,#1791);
#1793=PLANE('',#1792);
#1794=ORIENTED_EDGE('',*,*,#1713,.T.);
#1795=EDGE_LOOP('',(#1794));
#1796=FACE_BOUND('',#1795,.T.);
#1797=ADVANCED_FACE('F209',(#1796),#1793,.T.);
#1798=CARTESIAN_POINT('',(4.7624999999992,-76.2,-149.86));
#1799=DIRECTION('',(0.,0.,-1.));
#1800=DIRECTION('',(-1.,0.,0.));
#1801=AXIS2_PLACEMENT_3D('',#1798,#1799,#1800);
#1802=CYLINDRICAL_SURFACE('',#1801,2.1971);
#1803=CARTESIAN_POINT('',(4.7624999999992,-76.2,-149.86));
#1804=DIRECTION('',(0.,0.,-1.));
#1805=DIRECTION('',(-1.,0.,0.));
#1806=AXIS2_PLACEMENT_3D('',#1803,#1804,#1805);
#1807=CIRCLE('',#1806,2.1971);
#1808=CARTESIAN_POINT('',(2.5653999999992,-76.2,-149.86));
#1809=VERTEX_POINT('',#1808);
#1810=EDGE_CURVE('E200',#1809,#1809,#1807,.T.);
#1811=CARTESIAN_POINT('',(2.5653999999992,-76.2,-149.86));
#1812=CARTESIAN_POINT('',(2.5653999999992,-76.2,-150.01875));
#1813=CARTESIAN_POINT('',(2.5653999999992,-76.2,-150.1775));
#1814=CARTESIAN_POINT('',(2.5653999999992,-76.2,-150.495));
#1815=CARTESIAN_POINT('',(2.5653999999992,-76.2,-150.65375));
#1816=CARTESIAN_POINT('',(2.5653999999992,-76.2,-150.97125));
#1817=CARTESIAN_POINT('',(2.5653999999992,-76.2,-151.13));
#1818=CARTESIAN_POINT('',(2.5653999999992,-76.2,-151.4475));
#1819=CARTESIAN_POINT('',(2.5653999999992,-76.2,-151.60625));
#1820=CARTESIAN_POINT('',(2.5653999999992,-76.2,-151.92375));
#1821=CARTESIAN_POINT('',(2.5653999999992,-76.2,-152.0825));
#1822=CARTESIAN_POINT('',(2.5653999999992,-76.2,-152.4));
#1823=CARTESIAN_POINT('',(2.5653999999992,-76.2,-152.55875));
#1824=CARTESIAN_POINT('',(2.5653999999992,-76.2,-152.87625));
#1825=CARTESIAN_POINT('',(2.5653999999992,-76.2,-153.035));
#1826=CARTESIAN_POINT('',(2.5653999999992,-76.2,-153.3525));
#1827=CARTESIAN_POINT('',(2.5653999999992,-76.2,-153.51125));
#1828=CARTESIAN_POINT('',(2.5653999999992,-76.2,-153.82875));
#1829=CARTESIAN_POINT('',(2.5653999999992,-76.2,-153.9875));
#1830=CARTESIAN_POINT('',(2.5653999999992,-76.2,-154.305));
#1831=CARTESIAN_POINT('',(2.5653999999992,-76.2,-154.46375));
#1832=CARTESIAN_POINT('',(2.5653999999992,-76.2,-154.78125));
#1833=CARTESIAN_POINT('',(2.5653999999992,-76.2,-154.94));
#1834=CARTESIAN_POINT('',(2.5653999999992,-76.2,-155.2575));
#1835=CARTESIAN_POINT('',(2.5653999999992,-76.2,-155.41625));
#1836=CARTESIAN_POINT('',(2.5653999999992,-76.2,-155.73375));
#1837=CARTESIAN_POINT('',(2.5653999999992,-76.2,-155.8925));
#1838=CARTESIAN_POINT('',(2.5653999999992,-76.2,-156.21));
#1839=CARTESIAN_POINT('',(2.5653999999992,-76.2,-156.36875));
#1840=CARTESIAN_POINT('',(2.5653999999992,-76.2,-156.68625));
#1841=CARTESIAN_POINT('',(2.5653999999992,-76.2,-156.845));
#1842=CARTESIAN_POINT('',(2.5653999999992,-76.2,-157.1625));
#1843=CARTESIAN_POINT('',(2.5653999999992,-76.2,-157.32125));
#1844=CARTESIAN_POINT('',(2.5653999999992,-76.2,-157.63875));
#1845=CARTESIAN_POINT('',(2.5653999999992,-76.2,-157.7975));
#1846=CARTESIAN_POINT('',(2.5653999999992,-76.2,-158.115));
#1847=CARTESIAN_POINT('',(2.5653999999992,-76.2,-158.27375));
#1848=CARTESIAN_POINT('',(2.5653999999992,-76.2,-158.59125));
#1849=CARTESIAN_POINT('',(2.5653999999992,-76.2,-158.75));
#1850=CARTESIAN_POINT('',(2.5653999999992,-76.2,-159.0675));
#1851=CARTESIAN_POINT('',(2.5653999999992,-76.2,-159.22625));
#1852=CARTESIAN_POINT('',(2.5653999999992,-76.2,-159.54375));
#1853=CARTESIAN_POINT('',(2.5653999999992,-76.2,-159.7025));
#1854=CARTESIAN_POINT('',(2.5653999999992,-76.2,-160.02));
#1855=CARTESIAN_POINT('',(2.5653999999992,-76.2,-160.17875));
#1856=CARTESIAN_POINT('',(2.5653999999992,-76.2,-160.49625));
#1857=CARTESIAN_POINT('',(2.5653999999992,-76.2,-160.655));
#1858=CARTESIAN_POINT('',(2.5653999999992,-76.2,-160.9725));
#1859=CARTESIAN_POINT('',(2.5653999999992,-76.2,-161.13125));
#1860=CARTESIAN_POINT('',(2.5653999999992,-76.2,-161.44875));
#1861=CARTESIAN_POINT('',(2.5653999999992,-76.2,-161.6075));
#1862=CARTESIAN_POINT('',(2.5653999999992,-76.2,-161.925));
#1863=CARTESIAN_POINT('',(2.5653999999992,-76.2,-162.08375));
#1864=CARTESIAN_POINT('',(2.5653999999992,-76.2,-162.40125));
#1865=CARTESIAN_POINT('',(2.5653999999992,-76.2,-162.56));
#1866=CARTESIAN_POINT('',(2.5653999999992,-76.2,-162.8775));
#1867=CARTESIAN_POINT('',(2.5653999999992,-76.2,-163.03625));
#1868=CARTESIAN_POINT('',(2.5653999999992,-76.2,-163.35375));
#1869=CARTESIAN_POINT('',(2.5653999999992,-76.2,-163.5125));
#1870=CARTESIAN_POINT('',(2.5653999999992,-76.2,-163.83));
#1871=CARTESIAN_POINT('',(2.5653999999992,-76.2,-163.98875));
#1872=CARTESIAN_POINT('',(2.5653999999992,-76.2,-164.30625));
#1873=CARTESIAN_POINT('',(2.5653999999992,-76.2,-164.465));
#1874=CARTESIAN_POINT('',(2.5653999999992,-76.2,-164.7825));
#1875=CARTESIAN_POINT('',(2.5653999999992,-76.2,-164.94125));
#1876=CARTESIAN_POINT('',(2.5653999999992,-76.2,-165.1));
#1877=B_SPLINE_CURVE_WITH_KNOTS('',3,(#1811,#1812,#1813,#1814,#1815,#1816,#1817,#1818,#1819,
#1820,#1821,#1822,#1823,#1824,#1825,#1826,#1827,#1828,#1829,#1830,#1831,#1832,#1833,#1834,#1835,
#1836,#1837,#1838,#1839,#1840,#1841,#1842,#1843,#1844,#1845,#1846,#1847,#1848,#1849,#1850,#1851,
#1852,#1853,#1854,#1855,#1856,#1857,#1858,#1859,#1860,#1861,#1862,#1863,#1864,#1865,#1866,#1867,
#1868,#1869,#1870,#1871,#1872,#1873,#1874,#1875,#1876),.UNSPECIFIED.,.F.,.F.,(4,2,2,2,2,2,2,2,2,
2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,4),(0.,0.476249999999984,0.952499999999995,
1.42874999999998,1.90499999999999,2.38124999999997,2.85749999999998,3.33375,3.80999999999998,
4.28624999999999,4.76249999999998,5.23874999999999,5.715,6.19124999999998,6.66749999999999,
7.14374999999998,7.61999999999999,8.09625,8.57249999999998,9.04874999999999,9.52499999999998,
10.00125,10.4775,10.95375,11.43,11.90625,12.3825,12.85875,13.335,13.81125,14.2875,14.76375,
15.24),.UNSPECIFIED.);
#1878=EDGE_CURVE('BSEAM517',#1809,#30,#1877,.T.);
#1879=ORIENTED_EDGE('',*,*,#1810,.F.);
#1880=ORIENTED_EDGE('',*,*,#31,.T.);
#1881=ORIENTED_EDGE('',*,*,#1878,.T.);
#1882=ORIENTED_EDGE('',*,*,#1878,.F.);
#1883=EDGE_LOOP('',(#1879,#1881,#1880,#1882));
#1884=FACE_BOUND('',#1883,.T.);
#1885=ADVANCED_FACE('F517',(#1884),#1802,.F.);
#1886=CARTESIAN_POINT('',(4.7624999999992,-76.2,-149.86));
#1887=DIRECTION('',(0.,0.,-1.));
#1888=DIRECTION('',(-1.,0.,0.));
#1889=AXIS2_PLACEMENT_3D('',#1886,#1887,#1888);
#1890=PLANE('',#1889);
#1891=ORIENTED_EDGE('',*,*,#1810,.T.);
#1892=EDGE_LOOP('',(#1891));
#1893=FACE_BOUND('',#1892,.T.);
#1894=ADVANCED_FACE('F526',(#1893),#1890,.T.);
#1895=CLOSED_SHELL('',(#91,#177,#241,#318,#330,#342,#430,#439,#527,#536,#624,#633,#721,#730,
#818,#827,#915,#924,#1012,#1021,#1109,#1118,#1206,#1215,#1303,#1312,#1400,#1409,#1497,#1506,
#1594,#1603,#1691,#1700,#1788,#1797,#1885,#1894));
#1896=MANIFOLD_SOLID_BREP('B2',#1895);
#1897=ADVANCED_BREP_SHAPE_REPRESENTATION('',(#18,#1896),#14);
#1898=SHAPE_DEFINITION_REPRESENTATION(#9,#1897);
ENDSEC;
END-ISO-10303-21;
